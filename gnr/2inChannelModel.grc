options:
  parameters:
    generate_options: hb
    id: twoInChannelModel
    output_language: python
    title: twoInChannelModel
  states: {}

blocks:
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channel_taps
  id: parameter
  parameters:
    type: complex
    value: '0'
  states: {}
- name: channels_channel_model_0_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: channel_taps
  states: {}
- name: channels_channel_model_0_0_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: channel_taps
  states: {}
- name: noise_voltage
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: 1e6
  states: {}

connections:
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0_0_0, '0']
- [blocks_throttle2_1, '0', channels_channel_model_0_0_0_0, '0']
- [channels_channel_model_0_0_0, '0', blocks_add_xx_0, '0']
- [channels_channel_model_0_0_0_0, '0', blocks_add_xx_0, '1']
- [pad_source_0, '0', blocks_throttle2_0, '0']
- [pad_source_0_0, '0', blocks_throttle2_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
