options:
  parameters:
    author: trask-smith
    generate_options: qt_gui
    id: ZCCSPreamble2InputwithData
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: channel0_bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: channel_state
  id: variable
  parameters:
    value: np.fromfile(open("/tmp/zc_cs_state.bin", "rb"), dtype=np.complex64)[-1] if (os.path.exists("/tmp/zc_cs_state.bin") and os.path.getsize("/tmp/zc_cs_state.bin") >= 8) else 1.0+0j
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 2.41e9
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    start: '0.0001'
    step: '0.05'
    stop: '1'
    value: '0.5'
    widget: slider
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_1_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '1000'
    scale: 1/1000
    type: complex
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '1000'
    scale: 1/1000
    type: complex
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (139, 139)
    type: complex
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: (139, 139)
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[0.5+0j]*139'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[0.5+0j]*139'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Zadoff-Chu Sequence Generator
          Generates a continuous, repeating Zadoff-Chu sequence.
          """

          def __init__(self, root=1, length=139):
              # Initialize the sync block with no inputs and one complex output
              gr.sync_block.__init__(
                  self,
                  name='Zadoff-Chu Source',
                  in_sig=[],
                  out_sig=[np.complex64]
              )
              
              # Store parameters
              self.root = root
              self.length = length
              
              # Internal state
              self.idx = 0
              self.seq = self._generate_zc()

          def _generate_zc(self):
              """Calculates the ZC sequence based on current root and length."""
              n = np.arange(self.length)
              if self.length % 2 == 0:
                  # Even length formula
                  seq = np.exp(-1j * np.pi * self.root * (n ** 2) / self.length)
              else:
                  # Odd length formula
                  seq = np.exp(-1j * np.pi * self.root * n * (n + 1) / self.length)
              return seq.astype(np.complex64)

          def set_root(self, root):
              """Callback for the root variable."""
              self.root = root
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds on length change

          def set_length(self, length):
              """Callback for the length variable."""
              if length < 1:
                  length = 1
              self.length = int(length)
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds

          def work(self, input_items, output_items):
              out = output_items[0]
              n_output = len(out)
              
              # Fast array assignment to handle the repeating sequence
              remaining = n_output
              out_idx = 0
              
              while remaining > 0:
                  # Calculate how much of the sequence we can write in this loop
                  chunk_size = min(remaining, self.length - self.idx)
                  
                  # Write the chunk to the output buffer
                  out[out_idx:out_idx + chunk_size] = self.seq[self.idx:self.idx + chunk_size]
                  
                  # Update pointers and counters
                  self.idx = (self.idx + chunk_size) % self.length
                  out_idx += chunk_size
                  remaining -= chunk_size
                  
              return n_output
    length: '139'
    root: '1'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Zadoff-Chu Sequence Generator
          Generates a continuous, repeating Zadoff-Chu sequence.
          """

          def __init__(self, root=1, length=139):
              # Initialize the sync block with no inputs and one complex output
              gr.sync_block.__init__(
                  self,
                  name='Zadoff-Chu Source',
                  in_sig=[],
                  out_sig=[np.complex64]
              )
              
              # Store parameters
              self.root = root
              self.length = length
              
              # Internal state
              self.idx = 0
              self.seq = self._generate_zc()

          def _generate_zc(self):
              """Calculates the ZC sequence based on current root and length."""
              n = np.arange(self.length)
              if self.length % 2 == 0:
                  # Even length formula
                  seq = np.exp(-1j * np.pi * self.root * (n ** 2) / self.length)
              else:
                  # Odd length formula
                  seq = np.exp(-1j * np.pi * self.root * n * (n + 1) / self.length)
              return seq.astype(np.complex64)

          def set_root(self, root):
              """Callback for the root variable."""
              self.root = root
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds on length change

          def set_length(self, length):
              """Callback for the length variable."""
              if length < 1:
                  length = 1
              self.length = int(length)
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds

          def work(self, input_items, output_items):
              out = output_items[0]
              n_output = len(out)
              
              # Fast array assignment to handle the repeating sequence
              remaining = n_output
              out_idx = 0
              
              while remaining > 0:
                  # Calculate how much of the sequence we can write in this loop
                  chunk_size = min(remaining, self.length - self.idx)
                  
                  # Write the chunk to the output buffer
                  out[out_idx:out_idx + chunk_size] = self.seq[self.idx:self.idx + chunk_size]
                  
                  # Update pointers and counters
                  self.idx = (self.idx + chunk_size) % self.length
                  out_idx += chunk_size
                  remaining -= chunk_size
                  
              return n_output
    length: '139'
    root: '5'
  states: {}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          def __init__(self, roots=[1, 5], length=139, threshold_ratio=0.75):
              self.roots = roots
              self.num_roots = len(roots)
              self.length = length
              self.threshold_ratio = threshold_ratio

              out_types = [np.complex64] * (self.num_roots + 1)
              
              gr.sync_block.__init__(
                  self,
                  name='Multi-Root ZC & Combined Data (Stable)',
                  in_sig=[np.complex64],
                  out_sig=out_types
              )

              self.port_names = [f'msg_root_{r}' for r in self.roots]
              for name in self.port_names:
                  self.message_port_register_out(pmt.intern(name))

              self.last_h_vec = [1.0 + 0.0j] * self.num_roots
              self.last_data_avg = 1.0 + 0.0j
              
              self.is_collecting = False
              self.samples_collected = 0
              self.current_sum = 0.0 + 0.0j

              self.seq_dict = {r: self._generate_zc(r) for r in self.roots}
              self.set_history(self.length * 2)

          def _generate_zc(self, r):
              n = np.arange(self.length)
              if self.length % 2 == 0:
                  seq = np.exp(-1j * np.pi * r * (n ** 2) / self.length)
              else:
                  seq = np.exp(-1j * np.pi * r * n * (n + 1) / self.length)
              return seq.astype(np.complex64)

          def work(self, input_items, output_items):
              in_sig = input_items[0]
              n_output_samples = len(output_items[0])
              out_data_avg = output_items[self.num_roots]

              # --- Part 1: Peak Detection & Channel Estimation ---
              # We do this first so we can fire messages as soon as peaks appear
              for idx, r in enumerate(self.roots):
                  out_h_stream = output_items[idx]
                  port_name = self.port_names[idx]

                  corr = np.correlate(in_sig[:n_output_samples + self.length - 1], 
                                      self.seq_dict[r], mode='valid')
                  chan_est_list = corr / self.length
                  mags = np.abs(chan_est_list)

                  for i in range(n_output_samples):
                      if mags[i] >= self.threshold_ratio:
                          self.last_h_vec[idx] = chan_est_list[i]
                          self.message_port_pub(pmt.intern(port_name), pmt.from_complex(self.last_h_vec[idx]))

                          # CRITICAL FIX: Only trigger a NEW collection if we aren't already busy.
                          # This prevents the "reset-in-the-middle" bouncing.
                          if not self.is_collecting:
                              self.is_collecting = True
                              self.samples_collected = 0
                              self.current_sum = 0.0 + 0.0j

                      out_h_stream[i] = self.last_h_vec[idx]

              # --- Part 2: Synchronized Data Averaging ---
              for i in range(n_output_samples):
                  if self.is_collecting:
                      # We average the samples exactly 'length' samples after the preamble peak
                      self.current_sum += in_sig[i + self.length]
                      self.samples_collected += 1
                      
                      if self.samples_collected >= self.length:
                          self.last_data_avg = self.current_sum / self.length
                          self.is_collecting = False
                  
                  out_data_avg[i] = self.last_data_avg

              return n_output_samples
    length: '139'
    roots: '[1,5]'
    threshold_ratio: threshold
  states: {}
- name: epy_block_3_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class zmq_to_complex(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='ZMQ Msg to Complex',
                  in_sig=None, # No stream input
                  out_sig=[np.complex64] # Complex stream output
              )
              # Register input message port
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              
              # Initial value until first message arrives
              self.current_val = 1.0 + 0.0j

          def handle_msg(self, msg):
              # Convert PMT complex to Python complex
              if pmt.is_complex(msg):
                  self.current_val = pmt.to_complex(msg)
              # If it comes from a ZMQ PDU source, it might be a pair
              elif pmt.is_pair(msg):
                  data = pmt.cdr(msg)
                  if pmt.is_complex(data):
                      self.current_val = pmt.to_complex(data)

          def work(self, input_items, output_items):
              # Fill the entire output buffer with the latest received value
              output_items[0][:] = self.current_val
              return len(output_items[0])
  states: {}
- name: epy_block_3_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class zmq_to_complex(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='ZMQ Msg to Complex',
                  in_sig=None, # No stream input
                  out_sig=[np.complex64] # Complex stream output
              )
              # Register input message port
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              
              # Initial value until first message arrives
              self.current_val = 1.0 + 0.0j

          def handle_msg(self, msg):
              # Convert PMT complex to Python complex
              if pmt.is_complex(msg):
                  self.current_val = pmt.to_complex(msg)
              # If it comes from a ZMQ PDU source, it might be a pair
              elif pmt.is_pair(msg):
                  data = pmt.cdr(msg)
                  if pmt.is_complex(data):
                      self.current_val = pmt.to_complex(data)

          def work(self, input_items, output_items):
              # Fill the entire output buffer with the latest received value
              output_items[0][:] = self.current_val
              return len(output_items[0])
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: from math import pi as pi
  states: {}
- name: import_2
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Root1"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    name: '"Root5"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"IRoot1"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"IRoot5"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"DataI"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"QRoot1"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"QRoot5"'
    type: float
  states: {}
- name: qtgui_number_sink_1_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"DataQ"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0
    name: '"Client1Data"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0
    name: '"Client2Data"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0
    name: '"ServerReceivedData"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1
    name: '"Client1ProcodedData"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1
    name: '"Client2ProcodedData"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: twoInChannelModel_0_0
  id: twoInChannelModel
  parameters:
    channel_taps: 0.3-0.8j
    noise_voltage: '0.1'
    samp_rate: 1e6
  states: {}
- name: twoInChannelModel_0_0_0
  id: twoInChannelModel
  parameters:
    channel_taps: 0.5-0.5j
    noise_voltage: '0.1'
    samp_rate: 1e6
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://*:5555
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://*:5556
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0_1
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0_1_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
  states: {}

connections:
- [blocks_add_xx_0, '0', epy_block_3_0, '0']
- [blocks_complex_to_float_0_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_complex_to_float_0_0, '1', qtgui_number_sink_1_0, '0']
- [blocks_complex_to_float_0_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_complex_to_float_0_0_0, '1', qtgui_number_sink_1_0_0, '0']
- [blocks_complex_to_float_0_1_0, '0', qtgui_number_sink_0_1_0, '0']
- [blocks_complex_to_float_0_1_0, '1', qtgui_number_sink_1_1_0, '0']
- [blocks_divide_xx_0, '0', blocks_stream_mux_0, '1']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_divide_xx_0_0, '0', blocks_stream_mux_0_0, '1']
- [blocks_divide_xx_0_0, '0', qtgui_time_sink_x_0_0_1_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_complex_to_float_0_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_const_sink_x_0_1, '0']
- [blocks_null_source_0_0, '0', twoInChannelModel_0_0, '0']
- [blocks_null_source_0_0, '0', twoInChannelModel_0_0_0, '0']
- [blocks_stream_mux_0, '0', blocks_throttle2_0_0_0, '0']
- [blocks_stream_mux_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_throttle2_0_0, '0', twoInChannelModel_0_0_0, '1']
- [blocks_throttle2_0_0_0, '0', twoInChannelModel_0_0, '1']
- [blocks_vector_source_x_0, '0', blocks_divide_xx_0, '0']
- [blocks_vector_source_x_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_divide_xx_0_0, '0']
- [blocks_vector_source_x_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [epy_block_0, '0', blocks_stream_mux_0, '0']
- [epy_block_0_0, '0', blocks_stream_mux_0_0, '0']
- [epy_block_3_0, '0', blocks_moving_average_xx_0, '0']
- [epy_block_3_0, '1', blocks_moving_average_xx_0_0, '0']
- [epy_block_3_0, '2', blocks_complex_to_float_0_1_0, '0']
- [epy_block_3_0, '2', qtgui_time_sink_x_0_0_0_0, '0']
- [epy_block_3_0, msg_root_1, zeromq_pub_msg_sink_0, in]
- [epy_block_3_0, msg_root_5, zeromq_pub_msg_sink_0_0, in]
- [epy_block_3_0_0, '0', blocks_divide_xx_0, '1']
- [epy_block_3_0_0_0, '0', blocks_divide_xx_0_0, '1']
- [twoInChannelModel_0_0, '0', blocks_add_xx_0, '0']
- [twoInChannelModel_0_0_0, '0', blocks_add_xx_0, '1']
- [zeromq_sub_msg_source_0_1, out, epy_block_3_0_0, msg_in]
- [zeromq_sub_msg_source_0_1_0, out, epy_block_3_0_0_0, msg_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
