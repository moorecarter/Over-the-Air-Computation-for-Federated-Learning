options:
  parameters:
    author: trask-smith
    generate_options: qt_gui
    id: ZadoffChuCS
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: channel0_bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: channel_state
  id: variable
  parameters:
    value: np.fromfile(open("/tmp/zc_cs_state.bin", "rb"), dtype=np.complex64)[-1] if (os.path.exists("/tmp/zc_cs_state.bin") and os.path.getsize("/tmp/zc_cs_state.bin") >= 8) else 1.0+0j
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    start: '0.0001'
    step: '0.05'
    stop: '1'
    value: '0.5'
    widget: slider
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_0_1
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_0_2
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/zc_cs_state.bin
    type: complex
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '1000'
    scale: 1/1000
    type: complex
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '1000'
    scale: 1/1000
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/4
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '4'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/channel_state
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (255, 255)
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_1_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_1_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[0.2+0j]*255'
  states: {state: disabled}
- name: channels_channel_model_0_0_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: '0.1'
    seed: '0'
    taps: 0.7-0.2j
  states: {state: disabled}
- name: channels_channel_model_0_0_0_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: '0.1'
    seed: '0'
    taps: 0.7-0.2j
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Zadoff-Chu Sequence Generator
          Generates a continuous, repeating Zadoff-Chu sequence.
          """

          def __init__(self, root=1, length=139):
              # Initialize the sync block with no inputs and one complex output
              gr.sync_block.__init__(
                  self,
                  name='Zadoff-Chu Source',
                  in_sig=[],
                  out_sig=[np.complex64]
              )
              
              # Store parameters
              self.root = root
              self.length = length
              
              # Internal state
              self.idx = 0
              self.seq = self._generate_zc()

          def _generate_zc(self):
              """Calculates the ZC sequence based on current root and length."""
              n = np.arange(self.length)
              if self.length % 2 == 0:
                  # Even length formula
                  seq = np.exp(-1j * np.pi * self.root * (n ** 2) / self.length)
              else:
                  # Odd length formula
                  seq = np.exp(-1j * np.pi * self.root * n * (n + 1) / self.length)
              return seq.astype(np.complex64)

          def set_root(self, root):
              """Callback for the root variable."""
              self.root = root
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds on length change

          def set_length(self, length):
              """Callback for the length variable."""
              if length < 1:
                  length = 1
              self.length = int(length)
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds

          def work(self, input_items, output_items):
              out = output_items[0]
              n_output = len(out)
              
              # Fast array assignment to handle the repeating sequence
              remaining = n_output
              out_idx = 0
              
              while remaining > 0:
                  # Calculate how much of the sequence we can write in this loop
                  chunk_size = min(remaining, self.length - self.idx)
                  
                  # Write the chunk to the output buffer
                  out[out_idx:out_idx + chunk_size] = self.seq[self.idx:self.idx + chunk_size]
                  
                  # Update pointers and counters
                  self.idx = (self.idx + chunk_size) % self.length
                  out_idx += chunk_size
                  remaining -= chunk_size
                  
              return n_output
    length: '255'
    root: '1'
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Zadoff-Chu Sequence Generator
          Generates a continuous, repeating Zadoff-Chu sequence.
          """

          def __init__(self, root=1, length=139):
              # Initialize the sync block with no inputs and one complex output
              gr.sync_block.__init__(
                  self,
                  name='Zadoff-Chu Source',
                  in_sig=[],
                  out_sig=[np.complex64]
              )
              
              # Store parameters
              self.root = root
              self.length = length
              
              # Internal state
              self.idx = 0
              self.seq = self._generate_zc()

          def _generate_zc(self):
              """Calculates the ZC sequence based on current root and length."""
              n = np.arange(self.length)
              if self.length % 2 == 0:
                  # Even length formula
                  seq = np.exp(-1j * np.pi * self.root * (n ** 2) / self.length)
              else:
                  # Odd length formula
                  seq = np.exp(-1j * np.pi * self.root * n * (n + 1) / self.length)
              return seq.astype(np.complex64)

          def set_root(self, root):
              """Callback for the root variable."""
              self.root = root
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds on length change

          def set_length(self, length):
              """Callback for the length variable."""
              if length < 1:
                  length = 1
              self.length = int(length)
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds

          def work(self, input_items, output_items):
              out = output_items[0]
              n_output = len(out)
              
              # Fast array assignment to handle the repeating sequence
              remaining = n_output
              out_idx = 0
              
              while remaining > 0:
                  # Calculate how much of the sequence we can write in this loop
                  chunk_size = min(remaining, self.length - self.idx)
                  
                  # Write the chunk to the output buffer
                  out[out_idx:out_idx + chunk_size] = self.seq[self.idx:self.idx + chunk_size]
                  
                  # Update pointers and counters
                  self.idx = (self.idx + chunk_size) % self.length
                  out_idx += chunk_size
                  remaining -= chunk_size
                  
              return n_output
    length: '255'
    root: '1'
  states: {state: disabled}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Zadoff-Chu Sequence Generator
          Generates a continuous, repeating Zadoff-Chu sequence.
          """

          def __init__(self, root=1, length=139):
              # Initialize the sync block with no inputs and one complex output
              gr.sync_block.__init__(
                  self,
                  name='Zadoff-Chu Source',
                  in_sig=[],
                  out_sig=[np.complex64]
              )
              
              # Store parameters
              self.root = root
              self.length = length
              
              # Internal state
              self.idx = 0
              self.seq = self._generate_zc()

          def _generate_zc(self):
              """Calculates the ZC sequence based on current root and length."""
              n = np.arange(self.length)
              if self.length % 2 == 0:
                  # Even length formula
                  seq = np.exp(-1j * np.pi * self.root * (n ** 2) / self.length)
              else:
                  # Odd length formula
                  seq = np.exp(-1j * np.pi * self.root * n * (n + 1) / self.length)
              return seq.astype(np.complex64)

          def set_root(self, root):
              """Callback for the root variable."""
              self.root = root
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds on length change

          def set_length(self, length):
              """Callback for the length variable."""
              if length < 1:
                  length = 1
              self.length = int(length)
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds

          def work(self, input_items, output_items):
              out = output_items[0]
              n_output = len(out)
              
              # Fast array assignment to handle the repeating sequence
              remaining = n_output
              out_idx = 0
              
              while remaining > 0:
                  # Calculate how much of the sequence we can write in this loop
                  chunk_size = min(remaining, self.length - self.idx)
                  
                  # Write the chunk to the output buffer
                  out[out_idx:out_idx + chunk_size] = self.seq[self.idx:self.idx + chunk_size]
                  
                  # Update pointers and counters
                  self.idx = (self.idx + chunk_size) % self.length
                  out_idx += chunk_size
                  remaining -= chunk_size
                  
              return n_output
    length: '255'
    root: '5'
  states: {state: disabled}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Zadoff-Chu Sequence Generator
          Generates a continuous, repeating Zadoff-Chu sequence.
          """

          def __init__(self, root=1, length=139):
              # Initialize the sync block with no inputs and one complex output
              gr.sync_block.__init__(
                  self,
                  name='Zadoff-Chu Source',
                  in_sig=[],
                  out_sig=[np.complex64]
              )
              
              # Store parameters
              self.root = root
              self.length = length
              
              # Internal state
              self.idx = 0
              self.seq = self._generate_zc()

          def _generate_zc(self):
              """Calculates the ZC sequence based on current root and length."""
              n = np.arange(self.length)
              if self.length % 2 == 0:
                  # Even length formula
                  seq = np.exp(-1j * np.pi * self.root * (n ** 2) / self.length)
              else:
                  # Odd length formula
                  seq = np.exp(-1j * np.pi * self.root * n * (n + 1) / self.length)
              return seq.astype(np.complex64)

          def set_root(self, root):
              """Callback for the root variable."""
              self.root = root
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds on length change

          def set_length(self, length):
              """Callback for the length variable."""
              if length < 1:
                  length = 1
              self.length = int(length)
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds

          def work(self, input_items, output_items):
              out = output_items[0]
              n_output = len(out)
              
              # Fast array assignment to handle the repeating sequence
              remaining = n_output
              out_idx = 0
              
              while remaining > 0:
                  # Calculate how much of the sequence we can write in this loop
                  chunk_size = min(remaining, self.length - self.idx)
                  
                  # Write the chunk to the output buffer
                  out[out_idx:out_idx + chunk_size] = self.seq[self.idx:self.idx + chunk_size]
                  
                  # Update pointers and counters
                  self.idx = (self.idx + chunk_size) % self.length
                  out_idx += chunk_size
                  remaining -= chunk_size
                  
              return n_output
    length: '255'
    root: '1'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Zadoff-Chu Correlator with Latch
          Holds the last successful channel estimate (h) until a new peak is found.
          Initializes at 1+0j.
          """

          def __init__(self, root=1, length=139, threshold_ratio=0.75):
              gr.sync_block.__init__(
                  self,
                  name='ZC Correlator (Latched)',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              self.root = root
              self.length = length
              self.threshold_ratio = threshold_ratio
              
              # This is our 'memory' variable
              self.last_h = 1.0 + 0.0j
              
              self.seq = self._generate_zc()
              self.set_history(self.length)

          def _generate_zc(self):
              n = np.arange(self.length)
              if self.length % 2 == 0:
                  seq = np.exp(-1j * np.pi * self.root * (n ** 2) / self.length)
              else:
                  seq = np.exp(-1j * np.pi * self.root * n * (n + 1) / self.length)
              return seq.astype(np.complex64)

          def set_root(self, root):
              self.root = root
              self.seq = self._generate_zc()

          def set_length(self, length):
              self.length = int(max(1, length))
              self.seq = self._generate_zc()
              self.set_history(self.length)

          def work(self, input_items, output_items):
              in_sig = input_items[0]
              out_sig = output_items[0]
              
              # Calculate sliding correlation
              corr = np.correlate(in_sig, self.seq, mode='valid')
              chan_est_list = corr / self.length
              mags = np.abs(chan_est_list)

              # We must process samples one by one to update the state correctly
              # if a peak occurs mid-buffer.
              for i in range(len(out_sig)):
                  # If we find a new peak, update our memory
                  if mags[i] >= self.threshold_ratio:
                      self.last_h = chan_est_list[i]
                  
                  # Every output sample gets the 'last known good' estimate
                  out_sig[i] = self.last_h
                  
              return len(out_sig)
    length: '255'
    root: '1'
    threshold_ratio: threshold
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Multi-Output ZC Estimator
          - Outputs a unique stream for each root in the 'roots' list.
          - Latches the last valid channel estimate (h) until a new peak is found.
          - Designed to be connected to 'File Sink' or 'QT GUI Time Sink' blocks.
          """
          def __init__(self, roots=[1, 5], length=139, threshold_ratio=0.75):
              self.roots = roots
              self.num_roots = len(roots)
              
              gr.sync_block.__init__(
                  self,
                  name='Multi-Root ZC Estimator',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64] * self.num_roots
              )
              
              self.length = length
              self.threshold_ratio = threshold_ratio
              
              # Memory for latching: initialized at 1+0j for each root
              self.last_h_vec = [1.0 + 0.0j] * self.num_roots
              
              # Pre-generate sequences for each root
              self.seq_dict = {r: self._generate_zc(r) for r in self.roots}

              # Set history to ensure we have enough samples for the sliding correlation
              self.set_history(self.length)

          def _generate_zc(self, r):
              n = np.arange(self.length)
              if self.length % 2 == 0:
                  seq = np.exp(-1j * np.pi * r * (n ** 2) / self.length)
              else:
                  seq = np.exp(-1j * np.pi * r * n * (n + 1) / self.length)
              return seq.astype(np.complex64)

          def work(self, input_items, output_items):
              in_sig = input_items[0]
              n_output_samples = len(output_items[0])

              # Process each output port (one per root)
              for idx, r in enumerate(self.roots):
                  port_out = output_items[idx]
                  
                  # 1. Sliding Correlation
                  # Note: with history set, 'corr' length matches 'n_output_samples'
                  corr = np.correlate(in_sig, self.seq_dict[r], mode='valid')
                  chan_est_list = corr / self.length
                  mags = np.abs(chan_est_list)

                  # 2. Sample-by-Sample Latching
                  for i in range(n_output_samples):
                      if mags[i] >= self.threshold_ratio:
                          # Update the "remembered" channel state for this root
                          self.last_h_vec[idx] = chan_est_list[i]
                      
                      # Assign the current (or latched) state to the output stream
                      port_out[i] = self.last_h_vec[idx]

              return n_output_samples
    length: '255'
    roots: '[1,5]'
    threshold_ratio: '0.6'
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, root=1, length=139, threshold_ratio=0.75):
              gr.sync_block.__init__(
                  self,
                  name='ZC Correlator & Data Averager',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64, np.complex64] # Port 0: ZC State, Port 1: Data Average
              )
              self.root = root
              self.length = length
              self.threshold_ratio = threshold_ratio
              
              # Latched memories
              self.last_h = 1.0 + 0.0j
              self.last_data_avg = 1.0 + 0.0j
              
              # State machine for the data catcher
              self.is_collecting = False
              self.samples_collected = 0
              self.current_sum = 0.0 + 0.0j
              
              self.seq = self._generate_zc()
              self.set_history(self.length)

          def _generate_zc(self):
              n = np.arange(self.length)
              if self.length % 2 == 0:
                  seq = np.exp(-1j * np.pi * self.root * (n ** 2) / self.length)
              else:
                  seq = np.exp(-1j * np.pi * self.root * n * (n + 1) / self.length)
              return seq.astype(np.complex64)

          def work(self, input_items, output_items):
              in_sig = input_items[0]
              out_zc_state = output_items[0]
              out_data_avg = output_items[1]
              
              # 1. Sliding Correlation for the Preamble
              corr = np.correlate(in_sig, self.seq, mode='valid')
              chan_est_list = corr / self.length
              mags = np.abs(chan_est_list)

              for i in range(len(out_zc_state)):
                  # --- ZC PREAMBLE LOGIC (Port 0) ---
                  if mags[i] >= self.threshold_ratio:
                      # Instant update of channel state from ZC
                      self.last_h = chan_est_list[i]
                      
                      # Trigger the data catcher to start fresh
                      self.is_collecting = True
                      self.samples_collected = 0
                      self.current_sum = 0.0 + 0.0j
                  
                  # --- DATA CATCHER LOGIC (Port 1) ---
                  if self.is_collecting:
                      # The data follows the ZC. 
                      # in_sig[i + length - 1] is the sample exactly after the ZC correlation window
                      self.current_sum += in_sig[i + self.length-1]
                      self.samples_collected += 1
                      
                      if self.samples_collected >= self.length:
                          # Finalize the average for this frame
                          self.last_data_avg = self.current_sum / self.length
                          self.is_collecting = False
                  
                  # Write out the latched values to their respective ports
                  out_zc_state[i] = self.last_h
                  out_data_avg[i] = self.last_data_avg
                  
              return len(out_zc_state)
    length: '255'
    root: '1'
    threshold_ratio: '0.6'
  states: {state: disabled}
- name: epy_block_3_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt  # Added for message passing

      class blk(gr.sync_block):
          def __init__(self, root=1, length=139, threshold_ratio=0.75):
              gr.sync_block.__init__(
                  self,
                  name='ZC Correlator & Data Averager',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64, np.complex64]
              )
              self.root = root
              self.length = length
              self.threshold_ratio = threshold_ratio
              
              # Register the message output port
              self.message_port_register_out(pmt.intern('zc_state_msg'))
              
              self.last_h = 1.0 + 0.0j
              self.last_data_avg = 1.0 + 0.0j
              self.is_collecting = False
              self.samples_collected = 0
              self.current_sum = 0.0 + 0.0j
              
              self.seq = self._generate_zc()
              self.set_history(self.length)

          def _generate_zc(self):
              n = np.arange(self.length)
              if self.length % 2 == 0:
                  seq = np.exp(-1j * np.pi * self.root * (n ** 2) / self.length)
              else:
                  seq = np.exp(-1j * np.pi * self.root * n * (n + 1) / self.length)
              return seq.astype(np.complex64)

          def work(self, input_items, output_items):
              in_sig = input_items[0]
              out_zc_state = output_items[0]
              out_data_avg = output_items[1]
              
              corr = np.correlate(in_sig, self.seq, mode='valid')
              chan_est_list = corr / self.length
              mags = np.abs(chan_est_list)

              for i in range(len(out_zc_state)):
                  if mags[i] >= self.threshold_ratio:
                      self.last_h = chan_est_list[i]
                      
                      # --- NEW: Publish the state as a PMT message ---
                      # We do this only when the peak is hit to save CPU
                      self.message_port_pub(
                          pmt.intern('zc_state_msg'), 
                          pmt.from_complex(self.last_h)
                      )
                      
                      self.is_collecting = True
                      self.samples_collected = 0
                      self.current_sum = 0.0 + 0.0j
                  
                  if self.is_collecting:
                      self.current_sum += in_sig[i + self.length - 1]
                      self.samples_collected += 1
                      if self.samples_collected >= self.length:
                          self.last_data_avg = self.current_sum / self.length
                          self.is_collecting = False
                  
                  out_zc_state[i] = self.last_h
                  out_data_avg[i] = self.last_data_avg
                  
              return len(out_zc_state)
    length: '255'
    root: '1'
    threshold_ratio: '0.6'
  states: {state: disabled}
- name: epy_block_3_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class zmq_to_complex(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='ZMQ Msg to Complex',
                  in_sig=None, # No stream input
                  out_sig=[np.complex64] # Complex stream output
              )
              # Register input message port
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              
              # Initial value until first message arrives
              self.current_val = 1.0 + 0.0j

          def handle_msg(self, msg):
              # Convert PMT complex to Python complex
              if pmt.is_complex(msg):
                  self.current_val = pmt.to_complex(msg)
              # If it comes from a ZMQ PDU source, it might be a pair
              elif pmt.is_pair(msg):
                  data = pmt.cdr(msg)
                  if pmt.is_complex(data):
                      self.current_val = pmt.to_complex(data)

          def work(self, input_items, output_items):
              # Fill the entire output buffer with the latest received value
              output_items[0][:] = self.current_val
              return len(output_items[0])
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: from math import pi as pi
  states: {}
- name: import_2
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Root1"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    name: '"Root5"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_2
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"SRC"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"DST"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"DST"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"SRC"'
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"I"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"IRoot1"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"IRoot5"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"DataI"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"AmplitudeAttenuation(I)"'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Q"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"QRoot1"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"QRoot5"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"DataQ"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"PhaseOffset(Q)"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0
    name: '"SentZadoffChuSignal"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0
    name: '"ReceivedZadoffChuSignal"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"DST"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"SRC"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: twoInChannelModel_0_0
  id: twoInChannelModel
  parameters:
    channel_taps: 0.3-0.8j
    noise_voltage: '0.1'
    samp_rate: 1e6
  states: {state: disabled}
- name: twoInChannelModel_0_0_0
  id: twoInChannelModel
  parameters:
    channel_taps: 0.5-0.5j
    noise_voltage: '0.1'
    samp_rate: 1e6
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: target_freq
    clock_source0: external
    dev_addr: '"addr=192.168.10.5"'
    gain0: '15'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: target_freq
    clock_source0: external
    dev_addr: '"addr=192.168.10.4"'
    gain0: '25'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: target_freq
    clock_source0: external
    dev_addr: '"addr=192.168.10.3"'
    gain0: '25'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: target_freq
    clock_source0: external
    dev_addr: '"addr=192.168.10.3"'
    gain0: '25'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {state: disabled}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://*:5555
    timeout: '100'
  states: {state: disabled}
- name: zeromq_sub_msg_source_0_1
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
  states: {state: disabled}

connections:
- [blocks_add_xx_0, '0', epy_block_2, '0']
- [blocks_complex_to_float_0, '0', qtgui_number_sink_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_number_sink_1, '0']
- [blocks_complex_to_float_0_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_complex_to_float_0_0, '1', qtgui_number_sink_1_0, '0']
- [blocks_complex_to_float_0_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_complex_to_float_0_0_0, '1', qtgui_number_sink_1_0_0, '0']
- [blocks_complex_to_float_0_1, '0', qtgui_number_sink_0_1, '0']
- [blocks_complex_to_float_0_1, '1', qtgui_number_sink_1_1, '0']
- [blocks_complex_to_float_0_2, '0', qtgui_number_sink_0_2, '0']
- [blocks_complex_to_float_0_2, '1', qtgui_number_sink_1_2, '0']
- [blocks_divide_xx_0, '0', blocks_stream_mux_0, '1']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_complex_to_float_0_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_const_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_1_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', epy_block_3, '0']
- [blocks_multiply_const_vxx_0_0, '0', epy_block_3_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', epy_block_1, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_stream_mux_0, '1']
- [blocks_multiply_const_vxx_0_2, '0', blocks_throttle2_1_0, '0']
- [blocks_multiply_const_vxx_0_2, '0', uhd_usrp_sink_0_0, '0']
- [blocks_null_source_0_0, '0', twoInChannelModel_0_0, '0']
- [blocks_null_source_0_0, '0', twoInChannelModel_0_0_0, '0']
- [blocks_stream_mux_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_mux_0, '0', blocks_throttle2_1_1, '0']
- [blocks_throttle2_0_0, '0', twoInChannelModel_0_0_0, '1']
- [blocks_throttle2_0_0_0, '0', twoInChannelModel_0_0, '1']
- [blocks_throttle2_1, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle2_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle2_1_0, '0', channels_channel_model_0_0_0_0, '0']
- [blocks_throttle2_1_0_0, '0', channels_channel_model_0_0_0_0_0, '0']
- [blocks_throttle2_1_1, '0', qtgui_freq_sink_x_0_0_1, '0']
- [blocks_throttle2_1_1, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_vector_source_x_0, '0', blocks_divide_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [channels_channel_model_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [channels_channel_model_0_0_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [channels_channel_model_0_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [channels_channel_model_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [epy_block_0, '0', blocks_stream_mux_0, '0']
- [epy_block_0_0, '0', blocks_throttle2_0_0_0, '0']
- [epy_block_0_0_0, '0', blocks_throttle2_0_0, '0']
- [epy_block_0_1, '0', blocks_multiply_const_vxx_0_2, '0']
- [epy_block_0_1, '0', blocks_throttle2_1, '0']
- [epy_block_1, '0', blocks_complex_to_float_0_2, '0']
- [epy_block_1, '0', qtgui_const_sink_x_0_2, '0']
- [epy_block_2, '0', blocks_moving_average_xx_0, '0']
- [epy_block_2, '1', blocks_moving_average_xx_0_0, '0']
- [epy_block_3, '0', blocks_complex_to_float_0, '0']
- [epy_block_3, '0', blocks_file_sink_0_0, '0']
- [epy_block_3, '0', qtgui_const_sink_x_0, '0']
- [epy_block_3, '1', blocks_complex_to_float_0_1, '0']
- [epy_block_3_0, '0', blocks_complex_to_float_0, '0']
- [epy_block_3_0, '0', blocks_file_sink_0_0, '0']
- [epy_block_3_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_3_0, '1', blocks_complex_to_float_0_1, '0']
- [epy_block_3_0, zc_state_msg, zeromq_pub_msg_sink_0, in]
- [epy_block_3_0_0, '0', blocks_divide_xx_0, '1']
- [twoInChannelModel_0_0, '0', blocks_add_xx_0, '0']
- [twoInChannelModel_0_0_0, '0', blocks_add_xx_0, '1']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [uhd_usrp_source_0, '0', epy_block_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [zeromq_sub_msg_source_0_1, out, epy_block_3_0_0, msg_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
