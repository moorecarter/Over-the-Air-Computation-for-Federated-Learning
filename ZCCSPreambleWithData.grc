options:
  parameters:
    author: trask-smith
    generate_options: qt_gui
    id: ZCCSPreambleWithData
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: channel0_bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: channel_state
  id: variable
  parameters:
    value: np.fromfile(open("/tmp/zc_cs_state.bin", "rb"), dtype=np.complex64)[-1] if (os.path.exists("/tmp/zc_cs_state.bin") and os.path.getsize("/tmp/zc_cs_state.bin") >= 8) else 1.0+0j
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    start: '0.0001'
    step: '0.05'
    stop: '1'
    value: '0.5'
    widget: slider
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/zc_cs_state.bin
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/2.5
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2.5'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/channel_state
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (255, 255)
    type: complex
  states: {}
- name: blocks_throttle2_1_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_1_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[0.2+0j]*255'
  states: {}
- name: channels_channel_model_0_0_0_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: '0.1'
    seed: '0'
    taps: 0.7-0.2j
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Zadoff-Chu Sequence Generator
          Generates a continuous, repeating Zadoff-Chu sequence.
          """

          def __init__(self, root=1, length=139):
              # Initialize the sync block with no inputs and one complex output
              gr.sync_block.__init__(
                  self,
                  name='Zadoff-Chu Source',
                  in_sig=[],
                  out_sig=[np.complex64]
              )
              
              # Store parameters
              self.root = root
              self.length = length
              
              # Internal state
              self.idx = 0
              self.seq = self._generate_zc()

          def _generate_zc(self):
              """Calculates the ZC sequence based on current root and length."""
              n = np.arange(self.length)
              if self.length % 2 == 0:
                  # Even length formula
                  seq = np.exp(-1j * np.pi * self.root * (n ** 2) / self.length)
              else:
                  # Odd length formula
                  seq = np.exp(-1j * np.pi * self.root * n * (n + 1) / self.length)
              return seq.astype(np.complex64)

          def set_root(self, root):
              """Callback for the root variable."""
              self.root = root
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds on length change

          def set_length(self, length):
              """Callback for the length variable."""
              if length < 1:
                  length = 1
              self.length = int(length)
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds

          def work(self, input_items, output_items):
              out = output_items[0]
              n_output = len(out)
              
              # Fast array assignment to handle the repeating sequence
              remaining = n_output
              out_idx = 0
              
              while remaining > 0:
                  # Calculate how much of the sequence we can write in this loop
                  chunk_size = min(remaining, self.length - self.idx)
                  
                  # Write the chunk to the output buffer
                  out[out_idx:out_idx + chunk_size] = self.seq[self.idx:self.idx + chunk_size]
                  
                  # Update pointers and counters
                  self.idx = (self.idx + chunk_size) % self.length
                  out_idx += chunk_size
                  remaining -= chunk_size
                  
              return n_output
    length: '255'
    root: '1'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, root=1, length=139, threshold_ratio=0.75):
              gr.sync_block.__init__(
                  self,
                  name='ZC Correlator & Data Averager',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64, np.complex64] # Port 0: ZC State, Port 1: Data Average
              )
              self.root = root
              self.length = length
              self.threshold_ratio = threshold_ratio
              
              # Latched memories
              self.last_h = 1.0 + 0.0j
              self.last_data_avg = 1.0 + 0.0j
              
              # State machine for the data catcher
              self.is_collecting = False
              self.samples_collected = 0
              self.current_sum = 0.0 + 0.0j
              
              self.seq = self._generate_zc()
              self.set_history(self.length)

          def _generate_zc(self):
              n = np.arange(self.length)
              if self.length % 2 == 0:
                  seq = np.exp(-1j * np.pi * self.root * (n ** 2) / self.length)
              else:
                  seq = np.exp(-1j * np.pi * self.root * n * (n + 1) / self.length)
              return seq.astype(np.complex64)

          def work(self, input_items, output_items):
              in_sig = input_items[0]
              out_zc_state = output_items[0]
              out_data_avg = output_items[1]
              
              # 1. Sliding Correlation for the Preamble
              corr = np.correlate(in_sig, self.seq, mode='valid')
              chan_est_list = corr / self.length
              mags = np.abs(chan_est_list)

              for i in range(len(out_zc_state)):
                  # --- ZC PREAMBLE LOGIC (Port 0) ---
                  if mags[i] >= self.threshold_ratio:
                      # Instant update of channel state from ZC
                      self.last_h = chan_est_list[i]
                      
                      # Trigger the data catcher to start fresh
                      self.is_collecting = True
                      self.samples_collected = 0
                      self.current_sum = 0.0 + 0.0j
                  
                  # --- DATA CATCHER LOGIC (Port 1) ---
                  if self.is_collecting:
                      # The data follows the ZC. 
                      # in_sig[i + length - 1] is the sample exactly after the ZC correlation window
                      self.current_sum += in_sig[i + self.length-1]
                      self.samples_collected += 1
                      
                      if self.samples_collected >= self.length:
                          # Finalize the average for this frame
                          self.last_data_avg = self.current_sum / self.length
                          self.is_collecting = False
                  
                  # Write out the latched values to their respective ports
                  out_zc_state[i] = self.last_h
                  out_data_avg[i] = self.last_data_avg
                  
              return len(out_zc_state)
    length: '255'
    root: '1'
    threshold_ratio: '0.6'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: from math import pi as pi
  states: {}
- name: import_2
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"DST"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"SRC"'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"I"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"DataI"'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Q"'
    type: float
  states: {}
- name: qtgui_number_sink_1_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"DataQ"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"DST"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"SRC"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: target_freq
    clock_source0: external
    dev_addr: '"addr=192.168.10.4"'
    gain0: '25'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: target_freq
    clock_source0: external
    dev_addr: '"addr=192.168.10.3"'
    gain0: '25'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_number_sink_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_number_sink_1, '0']
- [blocks_complex_to_float_0_1, '0', qtgui_number_sink_0_1, '0']
- [blocks_complex_to_float_0_1, '1', qtgui_number_sink_1_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_1_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', epy_block_3, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_stream_mux_0, '1']
- [blocks_stream_mux_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_mux_0, '0', blocks_throttle2_1_1, '0']
- [blocks_throttle2_1_0_0, '0', channels_channel_model_0_0_0_0_0, '0']
- [blocks_throttle2_1_1, '0', qtgui_freq_sink_x_0_0_1, '0']
- [blocks_throttle2_1_1, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [channels_channel_model_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [epy_block_0, '0', blocks_stream_mux_0, '0']
- [epy_block_3, '0', blocks_complex_to_float_0, '0']
- [epy_block_3, '0', blocks_file_sink_0_0, '0']
- [epy_block_3, '0', qtgui_const_sink_x_0, '0']
- [epy_block_3, '1', blocks_complex_to_float_0_1, '0']
- [uhd_usrp_source_0_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
