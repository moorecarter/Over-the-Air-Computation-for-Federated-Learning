options:
  parameters:
    author: trask-smith
    generate_options: qt_gui
    id: ZeroMQMessages
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: channel0_bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: channel_taps
  id: variable
  parameters:
    value: 2-0.5j
  states: {}
- name: client_src
  id: variable
  parameters:
    value: '[0.3+0.3j]'
  states: {}
- name: csi_mode
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: 'True'
  states: {}
- name: csi_src
  id: variable
  parameters:
    value: (1.0+0.0j,1.0000+0.0000j,0.9997-0.0246j,0.9973-0.0739j,0.9891-0.1473j,0.9698-0.2439j,0.9325-0.3612j,0.8691-0.4947j,0.7713-0.6365j,0.6317-0.7752j,0.4457-0.8952j,0.2139-0.9768j,-0.0554-0.9985j,-0.3439-0.9390j,-0.6221-0.7829j,-0.8502-0.5264j,-0.9830-0.1837j,-0.9781+0.2079j,-0.8090+0.5878j,-0.4785+0.8781j,-0.0308+0.9995j,0.4457+0.8952j,0.8302+0.5575j,0.9988+0.0493j,0.8691-0.4947j,0.4457-0.8952j,-0.1534-0.9882j,-0.7136-0.7005j,-0.9939-0.1107j,-0.8370+0.5472j,-0.2737+0.9618j,0.4457+0.8952j,0.9411+0.3382j,0.9032-0.4291j,0.3090-0.9511j,-0.5000-0.8660j,-0.9830-0.1837j,-0.7634+0.6459j,0.0431+0.9991j,0.8302+0.5575j,0.9325-0.3612j,0.2139-0.9768j,-0.7136-0.7005j,-0.9667+0.2558j,-0.2499+0.9683j,0.7390+0.6737j,0.9325-0.3612j,0.0677-0.9977j,-0.8868-0.4622j,-0.7634+0.6459j,0.3324+0.9432j,1.0000+0.0000j,0.3090-0.9511j,-0.8233-0.5677j,-0.7634+0.6459j,0.4457+0.8952j,0.9698-0.2439j,-0.0554-0.9985j,-0.9939-0.1107j,-0.2499+0.9683j,0.9325+0.3612j,0.4457-0.8952j,-0.8629-0.5053j,-0.5421+0.8403j,0.8302+0.5575j,0.5524-0.8336j,-0.8502-0.5264j,-0.4785+0.8781j,0.9135+0.4067j,0.3090-0.9511j,-0.9830-0.1837j,-0.0308+0.9995j,0.9891-0.1473j,-0.3439-0.9390j,-0.8370+0.5472j,0.7390+0.6737j,0.4457-0.8952j,-0.9872-0.1595j,0.1656+0.9862j,0.8691-0.4947j,-0.7791-0.6269j,-0.2737+0.9618j,0.9891-0.1473j,-0.5626-0.8267j,-0.4785+0.8781j,1.0000+0.0000j,-0.5000-0.8660j,-0.4785+0.8781j,0.9973-0.0739j,-0.6221-0.7829j,-0.2737+0.9618j,0.9325-0.3612j,-0.8629-0.5053j,0.1656+0.9862j,0.6317-0.7752j,-0.9981+0.0616j,0.7390+0.6737j,-0.0554-0.9985j,-0.6412+0.7674j,0.9891-0.1473j,-0.8502-0.5264j,0.3324+0.9432j,0.3090-0.9511j,-0.8090+0.5878j,0.9997-0.0246j,-0.8502-0.5264j,0.4457+0.8952j,0.0677-0.9977j,-0.5421+0.8403j,0.8691-0.4947j,-0.9981+0.0616j,0.9325+0.3612j,-0.7136-0.7005j,0.4011+0.9160j,-0.0554-0.9985j,-0.2737+0.9618j,0.5524-0.8336j,-0.7634+0.6459j,0.9032-0.4291j,-0.9781+0.2079j,1.0000+0.0000j,-0.9830-0.1837j,0.9411+0.3382j,-0.8868-0.4622j,0.8302+0.5575j,-0.7791-0.6269j,0.7390+0.6737j,-0.7136-0.7005j,0.7049+0.7093j,-0.7136-0.7005j,0.7390+0.6737j,-0.7791-0.6269j,0.8302+0.5575j,-0.8868-0.4622j,0.9411+0.3382j,-0.9830-0.1837j,1.0000+0.0000j,-0.9781+0.2079j,0.9032-0.4291j,-0.7634+0.6459j,0.5524-0.8336j,-0.2737+0.9618j,-0.0554-0.9985j,0.4011+0.9160j,-0.7136-0.7005j,0.9325+0.3612j,-0.9981+0.0616j,0.8691-0.4947j,-0.5421+0.8403j,0.0677-0.9977j,0.4457+0.8952j,-0.8502-0.5264j,0.9997-0.0246j,-0.8090+0.5878j,0.3090-0.9511j,0.3324+0.9432j,-0.8502-0.5264j,0.9891-0.1473j,-0.6412+0.7674j,-0.0554-0.9985j,0.7390+0.6737j,-0.9981+0.0616j,0.6317-0.7752j,0.1656+0.9862j,-0.8629-0.5053j,0.9325-0.3612j,-0.2737+0.9618j,-0.6221-0.7829j,0.9973-0.0739j,-0.4785+0.8781j,-0.5000-0.8660j,1.0000+0.0000j,-0.4785+0.8781j,-0.5626-0.8267j,0.9891-0.1473j,-0.2737+0.9618j,-0.7791-0.6269j,0.8691-0.4947j,0.1656+0.9862j,-0.9872-0.1595j,0.4457-0.8952j,0.7390+0.6737j,-0.8370+0.5472j,-0.3439-0.9390j,0.9891-0.1473j,-0.0308+0.9995j,-0.9830-0.1837j,0.3090-0.9511j,0.9135+0.4067j,-0.4785+0.8781j,-0.8502-0.5264j,0.5524-0.8336j,0.8302+0.5575j,-0.5421+0.8403j,-0.8629-0.5053j,0.4457-0.8952j,0.9325+0.3612j,-0.2499+0.9683j,-0.9939-0.1107j,-0.0554-0.9985j,0.9698-0.2439j,0.4457+0.8952j,-0.7634+0.6459j,-0.8233-0.5677j,0.3090-0.9511j,1.0000+0.0000j,0.3324+0.9432j,-0.7634+0.6459j,-0.8868-0.4622j,0.0677-0.9977j,0.9325-0.3612j,0.7390+0.6737j,-0.2499+0.9683j,-0.9667+0.2558j,-0.7136-0.7005j,0.2139-0.9768j,0.9325-0.3612j,0.8302+0.5575j,0.0431+0.9991j,-0.7634+0.6459j,-0.9830-0.1837j,-0.5000-0.8660j,0.3090-0.9511j,0.9032-0.4291j,0.9411+0.3382j,0.4457+0.8952j,-0.2737+0.9618j,-0.8370+0.5472j,-0.9939-0.1107j,-0.7136-0.7005j,-0.1534-0.9882j,0.4457-0.8952j,0.8691-0.4947j,0.9988+0.0493j,0.8302+0.5575j,0.4457+0.8952j,-0.0308+0.9995j,-0.4785+0.8781j,-0.8090+0.5878j,-0.9781+0.2079j,-0.9830-0.1837j,-0.8502-0.5264j,-0.6221-0.7829j,-0.3439-0.9390j,-0.0554-0.9985j,0.2139-0.9768j,0.4457-0.8952j,0.6317-0.7752j,0.7713-0.6365j,0.8691-0.4947j,0.9325-0.3612j,0.9698-0.2439j,0.9891-0.1473j,0.9973-0.0739j,0.9997-0.0246j,1.0000+0.0000j)
  states: {}
- name: enable_2
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: 'False'
  states: {}
- name: enable_4
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: 'False'
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: reverse
  id: variable
  parameters:
    value: np.conjugate([0.5, -0.5, -1, 1])
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: threshold_2
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.1'
    stop: '1'
    value: '0.6'
  states: {}
- name: threshold_4
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.1'
    stop: '1'
    value: '0.6'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: '256'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: csi_mode
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: enable_2
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: enable_4
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: enable_4
    type: complex
  states: {}
- name: blocks_selector_0_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: csi_mode
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: csi_mode
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '256'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '256'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: csi_src
  states: {}
- name: blocks_vector_source_x_2_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: client_src
  states: {}
- name: blocks_vector_source_x_2_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: client_src
  states: {}
- name: blocks_vector_source_x_2_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: csi_src
    vlen: '256'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '256'
    type: complex
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: channel_taps
  states: {state: disabled}
- name: channels_channel_model_0_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: channel_taps
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          Gradient CSI Precoder:
          Takes an input stream of complex gradients and multiplies them by 1/H,
          where H is the most recent channel state received via ZMQ.
          """
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Gradient CSI Precoder',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              # Start with a weight of 0+0j. 
              # This prevents transmitting garbage gradients before the first H arrives.
              self.precoder_weight = np.complex64(0.0 + 0.0j)
              
              self.port_name = pmt.intern("csi_in")
              self.message_port_register_in(self.port_name)
              self.set_msg_handler(self.port_name, self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_complex(msg):
                  h_val = pmt.to_complex(msg)
                  
                  # Pure Zero-Forcing: w = 1 / H
                  # We use a tiny safeguard just to prevent a python crash if H is exactly 0
                  if np.abs(h_val) > 1e-12:
                      raw_weight = 1.0 / h_val
                  else:
                      raw_weight = 0.0 + 0.0j
                      
                  self.precoder_weight = np.complex64(raw_weight)

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # Multiply the gradients by the newest 1/H weight
              out[:] = in0 * self.precoder_weight
              
              return len(out)
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          def __init__(self, fft_size=256, u=1, threshold_factor=4.0, is_estimating=0):
              gr.sync_block.__init__(
                  self,
                  name='Integrated ZC Estimator',
                  in_sig=[(np.complex64, fft_size)],
                  out_sig=[np.complex64]
              )
              self.fft_size = fft_size
              self.u = u
              self.threshold_factor = threshold_factor
              self.is_estimating = is_estimating
              self.last_state = is_estimating

              # 1. Generate Local Reference
              n = np.arange(fft_size)
              zc = np.exp(-1j * np.pi * self.u * n * (n + 1) / fft_size).astype(np.complex64)
              
              # 2. Pre-calculate Reference FFT and conjugate it
              # This replicates the 'Multiply Conjugate' block behavior
              self.ref_fft_conj = np.conj(np.fft.fft(zc))
              
              self.current_h = 1.0 + 0.0j
              self.estimates_buffer = []
              self.port_name = pmt.intern("csi_out")
              self.message_port_register_out(self.port_name)

          def work(self, input_items, output_items):
              in_vecs = input_items[0]
              out = output_items[0]

              if self.last_state == 0 and self.is_estimating == 1:
                  self.estimates_buffer = []
              
              if self.last_state == 1 and self.is_estimating == 0:
                  if self.estimates_buffer:
                      weights = np.linspace(0.2, 1.0, len(self.estimates_buffer))
                      self.current_h = np.complex64(np.average(self.estimates_buffer, weights=weights))
                      self.message_port_pub(self.port_name, pmt.from_complex(self.current_h))
              
              self.last_state = self.is_estimating

              if self.is_estimating == 1:
                  for vec in in_vecs:
                      # 3. Replicate GRC Flow: FFT -> Mult Conj -> IFFT
                      sig_fft = np.fft.fft(vec)
                      corr_fft = sig_fft * self.ref_fft_conj
                      
                      # np.fft.ifft applies 1/N scaling automatically
                      impulse_response = np.fft.ifft(corr_fft)
                      
                      mags = np.abs(impulse_response)
                      peak_idx = np.argmax(mags)
                      
                      if mags[peak_idx] > (self.threshold_factor * np.mean(mags)):
                          # 4. Extract H
                          # We do NOT divide by fft_size here because ifft() already did it.
                          # If magnitude is still > 1.0, your transmitter has extra gain.
                          h_est = impulse_response[peak_idx]
                          
                          self.estimates_buffer.append(h_est)
                          self.current_h = np.complex64(h_est)

              # Output to Number Sink
              out[:] = self.current_h
              return len(out)
    fft_size: '256'
    is_estimating: csi_mode
    threshold_factor: threshold_2
    u: '1'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):

          def __init__(self, fft_size=256, threshold=0.1):
              gr.sync_block.__init__(
                  self,
                  name='CSI Reader',
                  in_sig=[(np.complex64, fft_size)],
                  out_sig=[(np.complex64, fft_size)]  # Vector output
              )

              self.fft_size = fft_size
              self.threshold = threshold

              # Message output port
              self.port_id = pmt.intern("csi_msg")
              self.message_port_register_out(self.port_id)

          def work(self, input_items, output_items):

              in_vectors = input_items[0]
              out_vectors = output_items[0]

              n_vectors = len(in_vectors)

              for i in range(n_vectors):

                  vec = in_vectors[i]

                  # Pass-through for debugging/sinks
                  out_vectors[i][:] = vec

                  mags = np.abs(vec)
                  peak_idx = np.argmax(mags)
                  peak_mag = mags[peak_idx]

                  norm_metric = peak_mag / (np.mean(mags) + 1e-12)
                  if norm_metric > self.threshold:

                      peak_complex = vec[peak_idx]
                      phase_rad = np.angle(peak_complex)
                      phase_deg = np.degrees(phase_rad)

                      # ---- Publish full CSI vector ----
                      csi_pmt = pmt.from_complex(peak_complex)

                      # Optional metadata
                      meta = pmt.make_dict()
                      meta = pmt.dict_add(
                          meta,
                          pmt.intern("peak_mag"),
                          pmt.from_double(float(peak_mag))
                      )
                      meta = pmt.dict_add(
                          meta,
                          pmt.intern("phase_deg"),
                          pmt.from_double(float(phase_deg))
                      )

                      msg = pmt.cons(meta, csi_pmt)

                      self.message_port_pub(self.port_id, msg)

              return n_vectors
    fft_size: '256'
    threshold: threshold_2
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          Gradient CSI Precoder:
          Takes an input stream of complex gradients and multiplies them by 1/H,
          where H is the most recent channel state received via ZMQ.
          """
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Gradient CSI Precoder',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              # Start with a weight of 0+0j. 
              # This prevents transmitting garbage gradients before the first H arrives.
              self.precoder_weight = np.complex64(0.0 + 0.0j)
              
              self.port_name = pmt.intern("csi_in")
              self.message_port_register_in(self.port_name)
              self.set_msg_handler(self.port_name, self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_complex(msg):
                  h_val = pmt.to_complex(msg)
                  
                  # Pure Zero-Forcing: w = 1 / H
                  # We use a tiny safeguard just to prevent a python crash if H is exactly 0
                  if np.abs(h_val) > 1e-12:
                      raw_weight = 1.0 / h_val
                  else:
                      raw_weight = 0.0 + 0.0j
                      
                  self.precoder_weight = np.complex64(raw_weight)

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # Multiply the gradients by the newest 1/H weight
              out[:] = in0 * self.precoder_weight
              
              return len(out)
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '256'
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(256)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '256'
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(256)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: '256'
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(256)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: from math import pi as pi
  states: {}
- name: import_2
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"DST"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"SRC2"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"SRC4"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"DST"'
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_1_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"HJ2"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"HJ4"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"J"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"HI2"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"HI4"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_1_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"I"'
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"SRC2"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    name: '"SRC4"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2_1
  id: qtgui_time_sink_x
  parameters:
    name: '"DST"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: uhd.tune_request(target_freq, lo_offset)
    clock_source0: external
    dev_addr: '"addr=192.168.10.2"'
    gain0: '15'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: uhd.tune_request(target_freq, lo_offset)
    clock_source0: external
    dev_addr: '"addr=192.168.10.4"'
    gain0: '15'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: uhd.tune_request(target_freq, lo_offset)
    clock_source0: internal
    dev_addr: '"addr=192.168.10.3"'
    gain0: '15'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: USRP2
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: USRP4
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: USRP2
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: USRP4
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://*:5555
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://*:5556
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0_1
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_selector_0_2, '0']
- [blocks_complex_to_float_0, '0', qtgui_number_sink_1_0_1, '0']
- [blocks_complex_to_float_0, '1', qtgui_number_sink_1_0_0_0, '0']
- [blocks_complex_to_float_0_0, '0', qtgui_number_sink_1_0_1_0, '0']
- [blocks_complex_to_float_0_0, '1', qtgui_number_sink_1_0_0_0_0, '0']
- [blocks_complex_to_float_0_0_0, '0', qtgui_number_sink_1_0_1_0_0, '0']
- [blocks_complex_to_float_0_0_0, '1', qtgui_number_sink_1_0_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_0_1, '0']
- [blocks_null_source_0, '0', blocks_selector_0_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0_0_0, '0']
- [blocks_selector_0, '0', blocks_selector_0_0, '1']
- [blocks_selector_0_0, '0', blocks_throttle2_1, '0']
- [blocks_selector_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_selector_0_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_selector_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_selector_0_0_0, '0', blocks_throttle2_1_0, '0']
- [blocks_selector_0_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_selector_0_0_0, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_selector_0_0_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_selector_0_0_1, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_selector_0_0_1, '1', blocks_stream_to_vector_0_0, '0']
- [blocks_selector_0_1, '0', blocks_selector_0_0_0, '1']
- [blocks_selector_0_2, '0', blocks_complex_to_float_0_0_0, '0']
- [blocks_selector_0_2, '1', blocks_selector_0_0_1, '0']
- [blocks_stream_to_vector_0_0, '0', epy_block_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle2_0_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle2_1, '0', channels_channel_model_0_0, '0']
- [blocks_throttle2_1, '0', virtual_sink_0, '0']
- [blocks_throttle2_1_0, '0', channels_channel_model_0_0_0, '0']
- [blocks_throttle2_1_0, '0', virtual_sink_0_0, '0']
- [blocks_vector_source_x_2, '0', blocks_selector_0, '1']
- [blocks_vector_source_x_2, '0', blocks_selector_0_1, '1']
- [blocks_vector_source_x_2_0, '0', epy_block_0, '0']
- [blocks_vector_source_x_2_0_0, '0', epy_block_0_1, '0']
- [blocks_vector_source_x_2_1, '0', fft_vxx_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_float_0, '0']
- [channels_channel_model_0_0, '0', virtual_sink_0, '0']
- [channels_channel_model_0_0_0, '0', virtual_sink_0_0, '0']
- [epy_block_0, '0', blocks_selector_0, '0']
- [epy_block_0_0, '0', blocks_complex_to_float_0_0, '0']
- [epy_block_0_0, csi_out, zeromq_pub_msg_sink_0_0, in]
- [epy_block_0_0_0, '0', blocks_vector_to_stream_0, '0']
- [epy_block_0_0_0, csi_msg, zeromq_pub_msg_sink_0, in]
- [epy_block_0_1, '0', blocks_selector_0_1, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_1, '0', epy_block_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_selector_0_2, '0']
- [uhd_usrp_source_0, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_2_1, '0']
- [virtual_source_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0_0, '0', blocks_throttle2_0_0, '0']
- [zeromq_sub_msg_source_0, out, epy_block_0, csi_in]
- [zeromq_sub_msg_source_0_1, out, epy_block_0_1, csi_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
