options:
  parameters:
    author: trask-smith
    generate_options: qt_gui
    id: ZeroMQMessages
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: channel0_bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: channel_taps
  id: variable
  parameters:
    value: 2-0.5j
  states: {}
- name: client_src
  id: variable
  parameters:
    value: '[0.3+0.3j]'
  states: {}
- name: csi_mode
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: 'True'
  states: {}
- name: csi_src
  id: variable
  parameters:
    value: '[1,1,1,1,1,-1,-1,1,1,-1,1,-1,1] + [0.5]*50 + [0]*100'
  states: {}
- name: enable_2
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: 'False'
  states: {}
- name: enable_4
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: 'False'
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: reverse
  id: variable
  parameters:
    value: np.conjugate([0.5, -0.5, -1, 1])
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: threshold_2
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.1'
    stop: '1'
    value: '0.6'
  states: {}
- name: threshold_4
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.1'
    stop: '1'
    value: '0.6'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '4000'
    max_iter: '4000'
    scale: 1/4000
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: csi_mode
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: enable_2
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: enable_4
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: enable_4
    type: complex
  states: {}
- name: blocks_selector_0_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: csi_mode
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: csi_mode
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: csi_src
  states: {}
- name: blocks_vector_source_x_2_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: client_src
  states: {}
- name: blocks_vector_source_x_2_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: client_src
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: channel_taps
  states: {state: disabled}
- name: channels_channel_model_0_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: channel_taps
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '1'
    w: 1/100*pi
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          Gradient CSI Precoder:
          Takes an input stream of complex gradients and multiplies them by 1/H,
          where H is the most recent channel state received via ZMQ.
          """
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Gradient CSI Precoder',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              # Start with a weight of 0+0j. 
              # This prevents transmitting garbage gradients before the first H arrives.
              self.precoder_weight = np.complex64(0.0 + 0.0j)
              
              self.port_name = pmt.intern("csi_in")
              self.message_port_register_in(self.port_name)
              self.set_msg_handler(self.port_name, self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_complex(msg):
                  h_val = pmt.to_complex(msg)
                  
                  # Pure Zero-Forcing: w = 1 / H
                  if np.abs(h_val) > 1e-12:
                      raw_weight = 1.0 / h_val
                  else:
                      raw_weight = 0.0 + 0.0j
                      
                  self.precoder_weight = np.complex64(raw_weight)

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # Multiply the gradients by the newest 1/H weight
              out[:] = in0 * self.precoder_weight
              
              return len(out)
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          Gradient CSI Precoder:
          Takes an input stream of complex gradients and multiplies them by 1/H,
          where H is the most recent channel state received via ZMQ.
          """
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Gradient CSI Precoder',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              # Start with a weight of 0+0j. 
              # This prevents transmitting garbage gradients before the first H arrives.
              self.precoder_weight = np.complex64(0.0 + 0.0j)
              
              self.port_name = pmt.intern("csi_in")
              self.message_port_register_in(self.port_name)
              self.set_msg_handler(self.port_name, self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_complex(msg):
                  h_val = pmt.to_complex(msg)
                  
                  # Pure Zero-Forcing: w = 1 / H
                  if np.abs(h_val) > 1e-12:
                      raw_weight = 1.0 / h_val
                  else:
                      raw_weight = 0.0 + 0.0j
                      
                  self.precoder_weight = np.complex64(raw_weight)

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # Multiply the gradients by the newest 1/H weight
              out[:] = in0 * self.precoder_weight
              
              return len(out)
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          Channel State Estimator:
          Runs correlation continuously to avoid buffer dropouts.
          Updates H while is_estimating is 1. 
          Publishes H via ZMQ only once when is_estimating transitions from 1 to 0.
          """
          def __init__(self, threshold=0.5, is_estimating=0):
              gr.sync_block.__init__(
                  self,
                  name='Channel State Estimator (Triggered)',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.threshold_factor = threshold
              self.is_estimating = is_estimating
              self.last_state = is_estimating
              
              self.barker = np.array([1,1,1,1,1,-1,-1,1,1,-1,1,-1,1], dtype=np.complex64)
              self.matched_filter = np.conj(np.flip(self.barker))
              self.ideal_peak_val = np.sum(np.abs(self.barker)**2)
              
              self.current_h = 1.0 + 0.0j
              self.has_valid_estimate = False # <-- NEW: Safeguard against bad ZMQ publishes
              
              self.port_name = pmt.intern("csi_out")
              self.message_port_register_out(self.port_name)
              self.set_history(len(self.barker))

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # 1. ALWAYS run the correlation to process the GNU Radio buffer
              # This prevents missing delayed samples when the async variable toggles
              corr = np.convolve(in0, self.matched_filter, mode='valid')
              
              if len(corr) > 0:
                  mags = np.abs(corr)
                  peak_idx = np.argmax(mags)
                  actual_threshold = self.threshold_factor * self.ideal_peak_val
                  
                  # Only update H if we found a peak AND we are supposed to be estimating
                  if mags[peak_idx] > actual_threshold and self.is_estimating == 1:
                      new_h_estimate = corr[peak_idx] / self.ideal_peak_val
                      
                      # First estimate snaps directly to the value instead of smoothing with 1.0+0j
                      if not self.has_valid_estimate:
                          self.current_h = new_h_estimate
                          self.has_valid_estimate = True
                      else:
                          self.current_h = (0.4 * new_h_estimate) + (0.6 * self.current_h)

              # 2. Edge Detection: Did we just STOP estimating? (1 -> 0)
              if self.last_state == 1 and self.is_estimating == 0:
                  if self.has_valid_estimate:
                      msg = pmt.from_complex(self.current_h)
                      self.message_port_pub(self.port_name, msg)
                      print(f"[CSI] Phase Ended. Final H Published: {self.current_h}")
                  else:
                      print("[CSI] Error: Phase Ended, but no valid Barker peak was found in the buffer!")

              # 3. Update the state tracker
              self.last_state = self.is_estimating

              out[:] = self.current_h
              return len(out)
    is_estimating: csi_mode
    threshold: threshold_2
  states: {}
- name: epy_block_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          Channel State Estimator:
          Runs correlation continuously to avoid buffer dropouts.
          Updates H while is_estimating is 1. 
          Publishes H via ZMQ only once when is_estimating transitions from 1 to 0.
          """
          def __init__(self, threshold=0.5, is_estimating=0):
              gr.sync_block.__init__(
                  self,
                  name='Channel State Estimator (Triggered)',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.threshold_factor = threshold
              self.is_estimating = is_estimating
              self.last_state = is_estimating
              
              self.barker = np.array([1,1,1,1,1,-1,-1,1,1,-1,1,-1,1], dtype=np.complex64)
              self.matched_filter = np.conj(np.flip(self.barker))
              self.ideal_peak_val = np.sum(np.abs(self.barker)**2)
              
              self.current_h = 1.0 + 0.0j
              self.has_valid_estimate = False # <-- NEW: Safeguard against bad ZMQ publishes
              
              self.port_name = pmt.intern("csi_out")
              self.message_port_register_out(self.port_name)
              self.set_history(len(self.barker))

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # 1. ALWAYS run the correlation to process the GNU Radio buffer
              # This prevents missing delayed samples when the async variable toggles
              corr = np.convolve(in0, self.matched_filter, mode='valid')
              
              if len(corr) > 0:
                  mags = np.abs(corr)
                  peak_idx = np.argmax(mags)
                  actual_threshold = self.threshold_factor * self.ideal_peak_val
                  
                  # Only update H if we found a peak AND we are supposed to be estimating
                  if mags[peak_idx] > actual_threshold and self.is_estimating == 1:
                      new_h_estimate = corr[peak_idx] / self.ideal_peak_val
                      
                      # First estimate snaps directly to the value instead of smoothing with 1.0+0j
                      if not self.has_valid_estimate:
                          self.current_h = new_h_estimate
                          self.has_valid_estimate = True
                      else:
                          self.current_h = (0.4 * new_h_estimate) + (0.6 * self.current_h)

              # 2. Edge Detection: Did we just STOP estimating? (1 -> 0)
              if self.last_state == 1 and self.is_estimating == 0:
                  if self.has_valid_estimate:
                      msg = pmt.from_complex(self.current_h)
                      self.message_port_pub(self.port_name, msg)
                      print(f"[CSI] Phase Ended. Final H Published: {self.current_h}")
                  else:
                      print("[CSI] Error: Phase Ended, but no valid Barker peak was found in the buffer!")

              # 3. Update the state tracker
              self.last_state = self.is_estimating

              out[:] = self.current_h
              return len(out)
    is_estimating: csi_mode
    threshold: threshold_2
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: from math import pi as pi
  states: {}
- name: import_2
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"DST"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"SRC2"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"SRC4"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"DST"'
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_1_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"HJ2"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"HJ4"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"J"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"HI2"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"HI4"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_1_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"I"'
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"SRC2"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    name: '"SRC4"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2_1
  id: qtgui_time_sink_x
  parameters:
    name: '"DST"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: uhd.tune_request(target_freq, lo_offset)
    clock_source0: external
    dev_addr: '"addr=192.168.10.2"'
    gain0: '25'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: uhd.tune_request(target_freq, lo_offset)
    clock_source0: external
    dev_addr: '"addr=192.168.10.4"'
    gain0: '25'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: uhd.tune_request(target_freq, lo_offset)
    clock_source0: internal
    dev_addr: '"addr=192.168.10.3"'
    gain0: '25'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: USRP2
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: USRP4
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: USRP2
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: USRP4
  states: {state: disabled}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://*:5555
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://*:5556
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0_1
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_selector_0_2, '0']
- [blocks_complex_to_float_0, '0', qtgui_number_sink_1_0_1, '0']
- [blocks_complex_to_float_0, '1', qtgui_number_sink_1_0_0_0, '0']
- [blocks_complex_to_float_0_0, '0', qtgui_number_sink_1_0_1_0, '0']
- [blocks_complex_to_float_0_0, '1', qtgui_number_sink_1_0_0_0_0, '0']
- [blocks_complex_to_float_0_0_0, '0', qtgui_number_sink_1_0_1_0_0, '0']
- [blocks_complex_to_float_0_0_0, '1', qtgui_number_sink_1_0_0_0_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_float_0_0_0, '0']
- [blocks_moving_average_xx_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0_0_0, '0']
- [blocks_selector_0, '0', blocks_selector_0_0, '1']
- [blocks_selector_0_0, '0', blocks_throttle2_1, '0']
- [blocks_selector_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_selector_0_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_selector_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_selector_0_0_0, '0', blocks_throttle2_1_0, '0']
- [blocks_selector_0_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_selector_0_0_0, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_selector_0_0_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_selector_0_0_1, '0', epy_block_0_0_0, '0']
- [blocks_selector_0_0_1, '1', epy_block_0_0_0_0, '0']
- [blocks_selector_0_1, '0', blocks_selector_0_0_0, '1']
- [blocks_selector_0_2, '0', blocks_moving_average_xx_0, '0']
- [blocks_selector_0_2, '1', blocks_selector_0_0_1, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle2_0_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle2_1, '0', channels_channel_model_0_0, '0']
- [blocks_throttle2_1_0, '0', channels_channel_model_0_0_0, '0']
- [blocks_vector_source_x_2, '0', blocks_selector_0, '1']
- [blocks_vector_source_x_2, '0', blocks_selector_0_1, '1']
- [blocks_vector_source_x_2_0, '0', epy_block_0, '0']
- [blocks_vector_source_x_2_0_0, '0', epy_block_0_0, '0']
- [channels_channel_model_0_0, '0', virtual_sink_0, '0']
- [channels_channel_model_0_0_0, '0', virtual_sink_0_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_float_0_0_0, '0']
- [epy_block_0, '0', blocks_selector_0, '0']
- [epy_block_0_0, '0', blocks_selector_0_1, '0']
- [epy_block_0_0_0, '0', blocks_complex_to_float_0, '0']
- [epy_block_0_0_0, csi_out, zeromq_pub_msg_sink_0, in]
- [epy_block_0_0_0_0, '0', blocks_complex_to_float_0_0, '0']
- [epy_block_0_0_0_0, csi_out, zeromq_pub_msg_sink_0_0, in]
- [uhd_usrp_source_0, '0', blocks_selector_0_2, '0']
- [uhd_usrp_source_0, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_2_1, '0']
- [virtual_source_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0_0, '0', blocks_throttle2_0_0, '0']
- [zeromq_sub_msg_source_0, out, epy_block_0, csi_in]
- [zeromq_sub_msg_source_0_1, out, epy_block_0_0, csi_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
