options:
  parameters:
    author: trask-smith
    generate_options: qt_gui
    id: ZeroMQMessages
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: channel0_bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: channel_taps
  id: variable
  parameters:
    value: 2-0.5j
  states: {}
- name: client_src
  id: variable
  parameters:
    value: '[0.3+0.3j]'
  states: {}
- name: csi_mode
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: 'True'
  states: {}
- name: csi_src
  id: variable
  parameters:
    value: '[1,1,1,1,1,-1,-1,1,1,-1,1,-1,1] + [0.5]*50 + [0]*100'
  states: {}
- name: enable_2
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: 'False'
  states: {}
- name: enable_4
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: 'False'
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: threshold_2
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.1'
    stop: '1'
    value: '0.6'
  states: {}
- name: threshold_4
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.1'
    stop: '1'
    value: '0.6'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '4000'
    max_iter: '4000'
    scale: 1/4000
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: csi_mode
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: enable_2
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: enable_4
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: enable_4
    type: complex
  states: {}
- name: blocks_selector_0_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: csi_mode
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: csi_mode
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: csi_src
  states: {}
- name: blocks_vector_source_x_2_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[0.55+0j]'
  states: {}
- name: blocks_vector_source_x_2_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[0.3+0j]'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: channel_taps
  states: {}
- name: channels_channel_model_0_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: channel_taps
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          Strict CSI Precoder:
          - Waits for a ZMQ message before processing any data.
          - Uses a strict 1/H reciprocal (Zero-Forcing).
          - Always uses the most recent H received.
          """
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Strict Waiting Precoder',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.precoder_weight = np.complex64(0.0 + 0.0j)
              self.is_ready = False  # The gate is closed by default

              self.port_name = pmt.intern("csi_in")
              self.message_port_register_in(self.port_name)
              self.set_msg_handler(self.port_name, self.handle_msg)

          def handle_msg(self, msg):
              try:
                  if pmt.is_complex(msg):
                      h_val = pmt.to_complex(msg)
                      
                      if np.abs(h_val) > 1e-12:
                          # STRICT 1/H logic. No scaling, no magic.
                          self.precoder_weight = np.complex64(1.0 / h_val)
                          self.is_ready = True
                          print(f"[Precoder] New CSI received: H={h_val}. Gate OPEN.")
                      else:
                          print("[Precoder] Warning: Received H is too small (near zero).")
                          self.is_ready = False
              except Exception as e:
                  print(f"[Precoder] Error parsing message: {e}")

          def work(self, input_items, output_items):
              # 1. Check if we have the CSI yet
              if not self.is_ready:
                  # We return 0, which tells the scheduler to wait.
                  # No data is consumed from the input, and no data is sent to the output.
                  return 0 

              # 2. If we are ready, process the most recent H
              in0 = input_items[0]
              out = output_items[0]
              
              # Apply the 1/H weight
              out[:] = in0 * self.precoder_weight
              
              return len(out)
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          Strict CSI Precoder:
          - Waits for a ZMQ message before processing any data.
          - Uses a strict 1/H reciprocal (Zero-Forcing).
          - Always uses the most recent H received.
          """
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Strict Waiting Precoder',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.precoder_weight = np.complex64(0.0 + 0.0j)
              self.is_ready = False  # The gate is closed by default

              self.port_name = pmt.intern("csi_in")
              self.message_port_register_in(self.port_name)
              self.set_msg_handler(self.port_name, self.handle_msg)

          def handle_msg(self, msg):
              try:
                  if pmt.is_complex(msg):
                      h_val = pmt.to_complex(msg)
                      
                      if np.abs(h_val) > 1e-12:
                          # STRICT 1/H logic. No scaling, no magic.
                          self.precoder_weight = np.complex64(1.0 / h_val)
                          self.is_ready = True
                          print(f"[Precoder] New CSI received: H={h_val}. Gate OPEN.")
                      else:
                          print("[Precoder] Warning: Received H is too small (near zero).")
                          self.is_ready = False
              except Exception as e:
                  print(f"[Precoder] Error parsing message: {e}")

          def work(self, input_items, output_items):
              # 1. Check if we have the CSI yet
              if not self.is_ready:
                  # We return 0, which tells the scheduler to wait.
                  # No data is consumed from the input, and no data is sent to the output.
                  return 0 

              # 2. If we are ready, process the most recent H
              in0 = input_items[0]
              out = output_items[0]
              
              # Apply the 1/H weight
              out[:] = in0 * self.precoder_weight
              
              return len(out)
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          Channel State Estimator:
          Runs power-normalized correlation continuously to avoid buffer dropouts.
          Updates H while is_estimating is 1. 
          Publishes H via ZMQ only once when is_estimating transitions from 1 to 0.
          """
          def __init__(self, threshold=0.5, is_estimating=0):
              gr.sync_block.__init__(
                  self,
                  name='Channel State Estimator (Triggered)',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # Threshold is now a value between 0.0 and 1.0
              self.threshold_factor = threshold
              self.is_estimating = is_estimating
              self.last_state = is_estimating
              
              self.barker = np.array([1,1,1,1,1,-1,-1,1,1,-1,1,-1,1], dtype=np.complex64)
              self.matched_filter = np.conj(np.flip(self.barker))
              self.ideal_peak_val = np.sum(np.abs(self.barker)**2)
              
              # Array of ones used to calculate the moving average power for normalization
              self.power_window_filter = np.ones(len(self.barker))
              
              self.current_h = 1.0 + 0.0j
              self.has_valid_estimate = False 
              
              self.port_name = pmt.intern("csi_out")
              self.message_port_register_out(self.port_name)
              self.set_history(len(self.barker))

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # 1. ALWAYS run the correlation to process the GNU Radio buffer
              corr = np.convolve(in0, self.matched_filter, mode='valid')
              
              if len(corr) > 0:
                  # 2. Calculate moving power window for gain-independent detection
                  power_window = np.convolve(np.abs(in0)**2, self.power_window_filter, mode='valid')
                  power_window[power_window == 0] = 1e-12 # Prevent divide-by-zero
                  
                  # Calculate Normalized Cross-Correlation Squared (Range: 0.0 to 1.0)
                  normalized_mags_sq = (np.abs(corr)**2) / (power_window * self.ideal_peak_val)
                  peak_idx = np.argmax(normalized_mags_sq)
                  
                  # Only update H if our normalized peak exceeds the threshold percentage
                  if normalized_mags_sq[peak_idx] > self.threshold_factor and self.is_estimating == 1:
                      
                      # 3. Calculate actual H using the un-normalized correlation 
                      # to preserve real-world amplitude attenuation and phase shift
                      new_h_estimate = corr[peak_idx] / self.ideal_peak_val
                      
                      # First estimate snaps directly to the value instead of smoothing
                      if not self.has_valid_estimate:
                          self.current_h = new_h_estimate
                          self.has_valid_estimate = True
                      else:
                          self.current_h = (0.4 * new_h_estimate) + (0.6 * self.current_h)

              # 4. Edge Detection: Did we just STOP estimating? (1 -> 0)
              if self.last_state == 1 and self.is_estimating == 0:
                  if self.has_valid_estimate:
                      msg = pmt.from_complex(self.current_h)
                      self.message_port_pub(self.port_name, msg)
                      print(f"[CSI] Phase Ended. Final H Published: {self.current_h}")
                  else:
                      print("[CSI] Error: Phase Ended, but no valid Barker peak was found in the buffer!")

              # 5. Update the state tracker
              self.last_state = self.is_estimating

              out[:] = self.current_h
              return len(out)
    is_estimating: csi_mode
    threshold: threshold_2
  states: {}
- name: epy_block_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np

      from gnuradio import gr

      import pmt


      class blk(gr.sync_block):

          """

          Channel State Estimator:

          Runs correlation continuously to avoid buffer dropouts.

          Updates H while is_estimating is 1. 

          Publishes H via ZMQ only once when is_estimating transitions from 1 to 0.

          """

          def __init__(self, threshold=0.5, is_estimating=0):

              gr.sync_block.__init__(

                  self,

                  name='Channel State Estimator (Triggered)',

                  in_sig=[np.complex64],

                  out_sig=[np.complex64]

              )

              self.threshold_factor = threshold

              self.is_estimating = is_estimating

              self.last_state = is_estimating

              

              self.barker = np.array([1,1,1,1,1,-1,-1,1,1,-1,1,-1,1], dtype=np.complex64)

              self.matched_filter = np.conj(np.flip(self.barker))

              self.ideal_peak_val = np.sum(np.abs(self.barker)**2)

              

              self.current_h = 1.0 + 0.0j

              self.has_valid_estimate = False # <-- NEW: Safeguard against bad ZMQ publishes

              

              self.port_name = pmt.intern("csi_out")

              self.message_port_register_out(self.port_name)

              self.set_history(len(self.barker))


          def work(self, input_items, output_items):

              in0 = input_items[0]

              out = output_items[0]

              

              # 1. ALWAYS run the correlation to process the GNU Radio buffer

              # This prevents missing delayed samples when the async variable toggles

              corr = np.convolve(in0, self.matched_filter, mode='valid')

              

              if len(corr) > 0:

                  mags = np.abs(corr)

                  peak_idx = np.argmax(mags)

                  actual_threshold = self.threshold_factor * self.ideal_peak_val

                  

                  # Only update H if we found a peak AND we are supposed to be estimating

                  if mags[peak_idx] > actual_threshold and self.is_estimating == 1:

                      new_h_estimate = corr[peak_idx] / self.ideal_peak_val

                      

                      # First estimate snaps directly to the value instead of smoothing with 1.0+0j

                      if not self.has_valid_estimate:

                          self.current_h = new_h_estimate

                          self.has_valid_estimate = True

                      else:

                          self.current_h = (0.4 * new_h_estimate) + (0.6 * self.current_h)


              # 2. Edge Detection: Did we just STOP estimating? (1 -> 0)

              if self.last_state == 1 and self.is_estimating == 0:

                  if self.has_valid_estimate:

                      msg = pmt.from_complex(self.current_h)

                      self.message_port_pub(self.port_name, msg)

                      print(f"[CSI] Phase Ended. Final H Published: {self.current_h}")

                  else:

                      print("[CSI] Error: Phase Ended, but no valid Barker peak was found in the buffer!")


              # 3. Update the state tracker

              self.last_state = self.is_estimating


              out[:] = self.current_h

              return len(out) 
    is_estimating: csi_mode
    threshold: threshold_4
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: from math import pi as pi
  states: {}
- name: import_2
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"DST"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"SRC2"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"SRC4"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"DST"'
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"I"'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"J"'
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"HI2"'
    type: float
  states: {}
- name: qtgui_number_sink_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"HJ2"'
    type: float
  states: {}
- name: qtgui_number_sink_4
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"HI4"'
    type: float
  states: {}
- name: qtgui_number_sink_5
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"HJ4"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0
    label1: Real
    label2: Imaginary
    name: '"Client1Data"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0
    label1: Real
    label2: Imaginary
    name: '"Client2Data"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0
    label1: Real
    label2: Imaginary
    name: '"ServerReceivedData"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1
    label1: Real
    label2: Imaginary
    name: '"Client1ProcodedData"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1
    label1: Real
    label2: Imaginary
    name: '"Client2ProcodedData"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"SRC2"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    name: '"SRC4"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2_1
  id: qtgui_time_sink_x
  parameters:
    name: '"DST"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: uhd.tune_request(target_freq, lo_offset)
    clock_source0: external
    dev_addr: '"addr=192.168.10.2"'
    gain0: '5'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: uhd.tune_request(target_freq, lo_offset)
    clock_source0: external
    dev_addr: '"addr=192.168.10.4"'
    gain0: '5'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: uhd.tune_request(target_freq, lo_offset)
    clock_source0: internal
    dev_addr: '"addr=192.168.10.3"'
    gain0: '15'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: USRP2
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: USRP4
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: USRP2
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: USRP4
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://*:5555
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://*:5556
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_0_1
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_selector_0_2, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_2_1, '0']
- [blocks_complex_to_float_0, '0', qtgui_number_sink_2, '0']
- [blocks_complex_to_float_0, '1', qtgui_number_sink_3, '0']
- [blocks_complex_to_float_0_0, '0', qtgui_number_sink_4, '0']
- [blocks_complex_to_float_0_0, '1', qtgui_number_sink_5, '0']
- [blocks_complex_to_float_0_0_0, '0', qtgui_number_sink_0, '0']
- [blocks_complex_to_float_0_0_0, '1', qtgui_number_sink_1, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_float_0_0_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0_0, '0']
- [blocks_null_source_0, '0', blocks_selector_0_0_0, '0']
- [blocks_selector_0, '0', blocks_selector_0_0, '1']
- [blocks_selector_0_0, '0', blocks_throttle2_1, '0']
- [blocks_selector_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_selector_0_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_selector_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_selector_0_0_0, '0', blocks_throttle2_1_0, '0']
- [blocks_selector_0_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_selector_0_0_0, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_selector_0_0_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_selector_0_0_1, '0', epy_block_0_0_0, '0']
- [blocks_selector_0_0_1, '1', blocks_null_sink_1, '0']
- [blocks_selector_0_0_1, '1', epy_block_0_0_0_0, '0']
- [blocks_selector_0_1, '0', blocks_selector_0_0_0, '1']
- [blocks_selector_0_2, '0', blocks_moving_average_xx_0, '0']
- [blocks_selector_0_2, '1', blocks_selector_0_0_1, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle2_0_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle2_0_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle2_1, '0', channels_channel_model_0_0, '0']
- [blocks_throttle2_1_0, '0', channels_channel_model_0_0_0, '0']
- [blocks_vector_source_x_2, '0', blocks_selector_0, '1']
- [blocks_vector_source_x_2, '0', blocks_selector_0_1, '1']
- [blocks_vector_source_x_2_0, '0', epy_block_0, '0']
- [blocks_vector_source_x_2_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_source_x_2_0_0, '0', epy_block_0_0, '0']
- [blocks_vector_source_x_2_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [channels_channel_model_0_0, '0', virtual_sink_0, '0']
- [channels_channel_model_0_0_0, '0', virtual_sink_0_0, '0']
- [epy_block_0, '0', blocks_selector_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [epy_block_0_0, '0', blocks_selector_0_1, '0']
- [epy_block_0_0, '0', qtgui_time_sink_x_0_0_1_0, '0']
- [epy_block_0_0_0, '0', blocks_complex_to_float_0, '0']
- [epy_block_0_0_0, csi_out, zeromq_pub_msg_sink_0, in]
- [epy_block_0_0_0_0, '0', blocks_complex_to_float_0_0, '0']
- [epy_block_0_0_0_0, csi_out, zeromq_pub_msg_sink_0_0, in]
- [uhd_usrp_source_0, '0', blocks_selector_0_2, '0']
- [uhd_usrp_source_0, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_2_1, '0']
- [virtual_source_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0_0, '0', blocks_throttle2_0_0, '0']
- [zeromq_sub_msg_source_0, out, epy_block_0, csi_in]
- [zeromq_sub_msg_source_0_1, out, epy_block_0_0, csi_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
