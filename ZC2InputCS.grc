options:
  parameters:
    author: trask-smith
    generate_options: qt_gui
    id: ZC2InputCS
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: channel0_bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: channel_state
  id: variable
  parameters:
    value: np.fromfile(open("/tmp/zc_cs_state.bin", "rb"), dtype=np.complex64)[-1] if (os.path.exists("/tmp/zc_cs_state.bin") and os.path.getsize("/tmp/zc_cs_state.bin") >= 8) else 1.0+0j
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    start: '0.0001'
    step: '0.05'
    stop: '1'
    value: '0.5'
    widget: slider
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '1000'
    scale: 1/1000
    type: complex
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '1000'
    scale: 1/1000
    type: complex
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Zadoff-Chu Sequence Generator
          Generates a continuous, repeating Zadoff-Chu sequence.
          """

          def __init__(self, root=1, length=139):
              # Initialize the sync block with no inputs and one complex output
              gr.sync_block.__init__(
                  self,
                  name='Zadoff-Chu Source',
                  in_sig=[],
                  out_sig=[np.complex64]
              )
              
              # Store parameters
              self.root = root
              self.length = length
              
              # Internal state
              self.idx = 0
              self.seq = self._generate_zc()

          def _generate_zc(self):
              """Calculates the ZC sequence based on current root and length."""
              n = np.arange(self.length)
              if self.length % 2 == 0:
                  # Even length formula
                  seq = np.exp(-1j * np.pi * self.root * (n ** 2) / self.length)
              else:
                  # Odd length formula
                  seq = np.exp(-1j * np.pi * self.root * n * (n + 1) / self.length)
              return seq.astype(np.complex64)

          def set_root(self, root):
              """Callback for the root variable."""
              self.root = root
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds on length change

          def set_length(self, length):
              """Callback for the length variable."""
              if length < 1:
                  length = 1
              self.length = int(length)
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds

          def work(self, input_items, output_items):
              out = output_items[0]
              n_output = len(out)
              
              # Fast array assignment to handle the repeating sequence
              remaining = n_output
              out_idx = 0
              
              while remaining > 0:
                  # Calculate how much of the sequence we can write in this loop
                  chunk_size = min(remaining, self.length - self.idx)
                  
                  # Write the chunk to the output buffer
                  out[out_idx:out_idx + chunk_size] = self.seq[self.idx:self.idx + chunk_size]
                  
                  # Update pointers and counters
                  self.idx = (self.idx + chunk_size) % self.length
                  out_idx += chunk_size
                  remaining -= chunk_size
                  
              return n_output
    length: '255'
    root: '1'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Zadoff-Chu Sequence Generator
          Generates a continuous, repeating Zadoff-Chu sequence.
          """

          def __init__(self, root=1, length=139):
              # Initialize the sync block with no inputs and one complex output
              gr.sync_block.__init__(
                  self,
                  name='Zadoff-Chu Source',
                  in_sig=[],
                  out_sig=[np.complex64]
              )
              
              # Store parameters
              self.root = root
              self.length = length
              
              # Internal state
              self.idx = 0
              self.seq = self._generate_zc()

          def _generate_zc(self):
              """Calculates the ZC sequence based on current root and length."""
              n = np.arange(self.length)
              if self.length % 2 == 0:
                  # Even length formula
                  seq = np.exp(-1j * np.pi * self.root * (n ** 2) / self.length)
              else:
                  # Odd length formula
                  seq = np.exp(-1j * np.pi * self.root * n * (n + 1) / self.length)
              return seq.astype(np.complex64)

          def set_root(self, root):
              """Callback for the root variable."""
              self.root = root
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds on length change

          def set_length(self, length):
              """Callback for the length variable."""
              if length < 1:
                  length = 1
              self.length = int(length)
              self.seq = self._generate_zc()
              self.idx = 0 # Reset index to avoid out-of-bounds

          def work(self, input_items, output_items):
              out = output_items[0]
              n_output = len(out)
              
              # Fast array assignment to handle the repeating sequence
              remaining = n_output
              out_idx = 0
              
              while remaining > 0:
                  # Calculate how much of the sequence we can write in this loop
                  chunk_size = min(remaining, self.length - self.idx)
                  
                  # Write the chunk to the output buffer
                  out[out_idx:out_idx + chunk_size] = self.seq[self.idx:self.idx + chunk_size]
                  
                  # Update pointers and counters
                  self.idx = (self.idx + chunk_size) % self.length
                  out_idx += chunk_size
                  remaining -= chunk_size
                  
              return n_output
    length: '255'
    root: '5'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Multi-Output ZC Estimator
          - Outputs a unique stream for each root in the 'roots' list.
          - Latches the last valid channel estimate (h) until a new peak is found.
          - Designed to be connected to 'File Sink' or 'QT GUI Time Sink' blocks.
          """
          def __init__(self, roots=[1, 5], length=139, threshold_ratio=0.75):
              self.roots = roots
              self.num_roots = len(roots)
              
              gr.sync_block.__init__(
                  self,
                  name='Multi-Root ZC Estimator',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64] * self.num_roots
              )
              
              self.length = length
              self.threshold_ratio = threshold_ratio
              
              # Memory for latching: initialized at 1+0j for each root
              self.last_h_vec = [1.0 + 0.0j] * self.num_roots
              
              # Pre-generate sequences for each root
              self.seq_dict = {r: self._generate_zc(r) for r in self.roots}

              # Set history to ensure we have enough samples for the sliding correlation
              self.set_history(self.length)

          def _generate_zc(self, r):
              n = np.arange(self.length)
              if self.length % 2 == 0:
                  seq = np.exp(-1j * np.pi * r * (n ** 2) / self.length)
              else:
                  seq = np.exp(-1j * np.pi * r * n * (n + 1) / self.length)
              return seq.astype(np.complex64)

          def work(self, input_items, output_items):
              in_sig = input_items[0]
              n_output_samples = len(output_items[0])

              # Process each output port (one per root)
              for idx, r in enumerate(self.roots):
                  port_out = output_items[idx]
                  
                  # 1. Sliding Correlation
                  # Note: with history set, 'corr' length matches 'n_output_samples'
                  corr = np.correlate(in_sig, self.seq_dict[r], mode='valid')
                  chan_est_list = corr / self.length
                  mags = np.abs(chan_est_list)

                  # 2. Sample-by-Sample Latching
                  for i in range(n_output_samples):
                      if mags[i] >= self.threshold_ratio:
                          # Update the "remembered" channel state for this root
                          self.last_h_vec[idx] = chan_est_list[i]
                      
                      # Assign the current (or latched) state to the output stream
                      port_out[i] = self.last_h_vec[idx]

              return n_output_samples
    length: '255'
    roots: '[1,5]'
    threshold_ratio: threshold
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: from math import pi as pi
  states: {}
- name: import_2
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Root1"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    name: '"Root5"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"IRoot1"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"IRoot5"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"QRoot1"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"QRoot5"'
    type: float
  states: {}
- name: twoInChannelModel_0_0
  id: twoInChannelModel
  parameters:
    channel_taps: 0.3-0.8j
    noise_voltage: '0.1'
    samp_rate: 1e6
  states: {}
- name: twoInChannelModel_0_0_0
  id: twoInChannelModel
  parameters:
    channel_taps: 0.5-0.5j
    noise_voltage: '0.1'
    samp_rate: 1e6
  states: {}

connections:
- [blocks_add_xx_0, '0', epy_block_2, '0']
- [blocks_complex_to_float_0_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_complex_to_float_0_0, '1', qtgui_number_sink_1_0, '0']
- [blocks_complex_to_float_0_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_complex_to_float_0_0_0, '1', qtgui_number_sink_1_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_complex_to_float_0_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_const_sink_x_0_1, '0']
- [blocks_null_source_0_0, '0', twoInChannelModel_0_0, '0']
- [blocks_null_source_0_0, '0', twoInChannelModel_0_0_0, '0']
- [blocks_throttle2_0_0, '0', twoInChannelModel_0_0_0, '1']
- [blocks_throttle2_0_0_0, '0', twoInChannelModel_0_0, '1']
- [epy_block_0_0, '0', blocks_throttle2_0_0_0, '0']
- [epy_block_0_0_0, '0', blocks_throttle2_0_0, '0']
- [epy_block_2, '0', blocks_moving_average_xx_0, '0']
- [epy_block_2, '1', blocks_moving_average_xx_0_0, '0']
- [twoInChannelModel_0_0, '0', blocks_add_xx_0, '0']
- [twoInChannelModel_0_0_0, '0', blocks_add_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
