options:
  parameters:
    author: Carter Moore
    description: Receiver for channel state estimation test
    generate_options: qt_gui
    id: rx
    output_language: python
    title: Reciever_CSI
  states: {}

blocks:
- name: channel0_bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: channel_taps
  id: variable
  parameters:
    value: 2-0.5j
  states: {}
- name: client_src
  id: variable
  parameters:
    value: '[0.7]'
  states: {}
- name: csi_src
  id: variable
  parameters:
    value: '[1,1,1,1,1,-1,-1,1,1,-1,1,-1,1] + [0.5]*50 + [0]*100'
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: reverse
  id: variable
  parameters:
    value: np.conjugate([0.5, -0.5, -1, 1])
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: threshold_2
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.1'
    stop: '1'
    value: '0.6'
  states: {}
- name: threshold_4
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.1'
    stop: '1'
    value: '0.6'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/csi_2_state.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/csi_4_state.bin
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: 1/10000
    type: complex
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: 1/10000
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: csi_src
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: channel_taps
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class channel_state_estimator(gr.sync_block):
          def __init__(self, threshold=0.5, alpha=0.1): # Added alpha for smoothing
              gr.sync_block.__init__(self,
                  name='Channel State Estimator (H)',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64])
              
              self.barker = np.array([1,1,1,1,1,-1,-1,1,1,-1,1,-1,1], dtype=np.complex64)
              self.matched_filter = np.conj(np.flip(self.barker))
              self.ideal_peak_val = np.sum(np.abs(self.barker)**2)
              self.threshold = threshold * self.ideal_peak_val
              
              self.alpha = alpha 
              self.current_h = 1.0 + 0.0j 
              self.set_history(len(self.barker))

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
          
              corr = np.convolve(in0, self.matched_filter, mode='valid')
              mags = np.abs(corr)
          
          # 1. Find the single best candidate in this buffer
              peak_idx = np.argmax(mags)
          
          # 2. Only update if the best peak is actually valid
              if mags[peak_idx] > self.threshold:
                  new_h_estimate = corr[peak_idx] / self.ideal_peak_val
              # Faster alpha (e.g., 0.4) to track the "waves" you're seeing
                  self.current_h = (0.4 * new_h_estimate) + (0.6 * self.current_h)
          
          # 3. Always drive the output with the most recent valid state
              out[:] = self.current_h
              return len(out)
    alpha: '0.25'
    threshold: threshold_2
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class channel_state_estimator(gr.sync_block):
          def __init__(self, threshold=0.5, alpha=0.1): # Added alpha for smoothing
              gr.sync_block.__init__(self,
                  name='Channel State Estimator (H)',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64])
              
              self.barker = np.array([1,1,1,1,1,-1,-1,1,1,-1,1,-1,1], dtype=np.complex64)
              self.matched_filter = np.conj(np.flip(self.barker))
              self.ideal_peak_val = np.sum(np.abs(self.barker)**2)
              self.threshold = threshold * self.ideal_peak_val
              
              self.alpha = alpha 
              self.current_h = 1.0 + 0.0j 
              self.set_history(len(self.barker))

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
          
              corr = np.convolve(in0, self.matched_filter, mode='valid')
              mags = np.abs(corr)
          
          # 1. Find the single best candidate in this buffer
              peak_idx = np.argmax(mags)
          
          # 2. Only update if the best peak is actually valid
              if mags[peak_idx] > self.threshold:
                  new_h_estimate = corr[peak_idx] / self.ideal_peak_val
              # Faster alpha (e.g., 0.4) to track the "waves" you're seeing
                  self.current_h = (0.4 * new_h_estimate) + (0.6 * self.current_h)
          
          # 3. Always drive the output with the most recent valid state
              out[:] = self.current_h
              return len(out)
    alpha: '0.25'
    threshold: threshold_4
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: from math import pi as pi
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"DST2"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"DST4"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"SRC"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"DST2"'
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"DST4"'
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_number_sink_1_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"HJ2"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"HJ4"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"HI2"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"HI4"'
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"SRC"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    name: '"SRC_NOISE"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2_1
  id: qtgui_time_sink_x
  parameters:
    name: '"DST2"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"DST4"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: uhd.tune_request(target_freq, lo_offset)
    clock_source0: internal
    dev_addr: '"addr=192.168.10.3"'
    gain0: '25'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: uhd.tune_request(target_freq, lo_offset)
    clock_source0: external
    dev_addr: '"addr=192.168.10.2"'
    gain0: '25'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: uhd.tune_request(target_freq, lo_offset)
    clock_source0: external
    dev_addr: '"addr=192.168.10.4"'
    gain0: '25'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: USRP
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: USRP
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: USRP
  states: {state: disabled}

connections:
- [blocks_complex_to_float_0, '0', qtgui_number_sink_1_0_1, '0']
- [blocks_complex_to_float_0, '1', qtgui_number_sink_1_0_0_0, '0']
- [blocks_complex_to_float_0_0, '0', qtgui_number_sink_1_0_1_0, '0']
- [blocks_complex_to_float_0_0, '1', qtgui_number_sink_1_0_0_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_throttle2_0, '0', epy_block_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle2_0_0, '0', epy_block_0_0_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_throttle2_1, '0', channels_channel_model_0_0, '0']
- [blocks_throttle2_1, '0', uhd_usrp_sink_0, '0']
- [blocks_vector_source_x_2, '0', blocks_throttle2_1, '0']
- [blocks_vector_source_x_2, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_source_x_2, '0', qtgui_time_sink_x_2, '0']
- [blocks_vector_source_x_2, '0', uhd_usrp_sink_0, '0']
- [channels_channel_model_0_0, '0', qtgui_time_sink_x_2_0, '0']
- [channels_channel_model_0_0, '0', virtual_sink_0, '0']
- [epy_block_0_0, '0', blocks_complex_to_float_0, '0']
- [epy_block_0_0, '0', blocks_file_sink_0, '0']
- [epy_block_0_0, '0', blocks_moving_average_xx_0, '0']
- [epy_block_0_0_0, '0', blocks_complex_to_float_0_0, '0']
- [epy_block_0_0_0, '0', blocks_file_sink_0_0, '0']
- [epy_block_0_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [uhd_usrp_source_0, '0', epy_block_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_2_1, '0']
- [uhd_usrp_source_0_0, '0', epy_block_0_0_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_time_sink_x_2_1_0, '0']
- [virtual_source_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0_0, '0', blocks_throttle2_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
