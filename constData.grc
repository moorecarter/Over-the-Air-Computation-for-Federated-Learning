options:
  parameters:
    author: trask-smith
    generate_options: qt_gui
    id: constData
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: H2_state
  id: variable
  parameters:
    value: np.fromfile(open("/tmp/csi_2_state.bin", "rb"), dtype=np.complex64)[-1] if (os.path.exists("/tmp/csi_2_state.bin") and os.path.getsize("/tmp/csi_2_state.bin") >= 8) else 1.0+0j
  states: {}
- name: H4_state
  id: variable
  parameters:
    value: np.fromfile(open("/tmp/csi_4_state.bin", "rb"), dtype=np.complex64)[-1] if (os.path.exists("/tmp/csi_4_state.bin") and os.path.getsize("/tmp/csi_4_state.bin") >= 8) else 1.0+0j
  states: {}
- name: channel0_bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: channel_taps
  id: variable
  parameters:
    value: 2-0.5j
  states: {}
- name: client_src
  id: variable
  parameters:
    value: '[0.7]'
  states: {}
- name: correlation_th
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.1'
    stop: '1'
    value: '0.9'
  states: {}
- name: csi_src
  id: variable
  parameters:
    value: '[1,1,1,1,1,-1,-1,1,1,-1,1,-1,1] + [0.5]*50 + [0]*100'
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: reverse
  id: variable
  parameters:
    value: np.conjugate([0.5, -0.5, -1, 1])
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/H2_state
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/H4_state
    type: complex
  states: {}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[0.07+0j]'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '1'
    w: 2*pi/100
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: from math import pi as pi
  states: {}
- name: import_2
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"DST"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"SRC"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"DST"'
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_number_sink_1_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"H_I"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"H_J"'
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"SRC"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2_1
  id: qtgui_time_sink_x
  parameters:
    name: '"DST"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: uhd.tune_request(target_freq, lo_offset)
    clock_source0: external
    dev_addr: '"addr=192.168.10.2"'
    gain0: '25'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: uhd.tune_request(target_freq, lo_offset)
    clock_source0: external
    dev_addr: '"addr=192.168.10.4"'
    gain0: '25'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: channel0_bandwidth
    center_freq0: uhd.tune_request(target_freq, lo_offset)
    clock_source0: internal
    dev_addr: '"addr=192.168.10.3"'
    gain0: '25'
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_number_sink_1_0_1, '0']
- [blocks_complex_to_float_0, '1', qtgui_number_sink_1_0_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', uhd_usrp_sink_0_0, '0']
- [blocks_vector_source_x_2, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vector_source_x_2, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_vector_source_x_2, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_source_x_2, '0', qtgui_time_sink_x_2, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_float_0, '0']
- [uhd_usrp_source_0, '0', digital_costas_loop_cc_0, '0']
- [uhd_usrp_source_0, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_2_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
